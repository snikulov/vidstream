require /home/snikulov/work/yocto/Daisy/poky/meta/recipes-sato/images/core-image-sato-sdk.bb
IMAGE_INSTALL = "perl-module-b-lint kernel-module-rc-leadtek-y04g0051 kernel-module-async-xor kernel-module-orinoco-usb kernel-module-spi-dw-mmio kernel-module-dummy kernel-module-ad7280a sysvinit-inittab matchbox-keyboard-applet kernel-module-g-mass-storage kernel-module-hmc5843 libxcb-glx kernel-module-emc6w201 kernel-module-plat-nand kernel-module-ar7part gnutls kernel-module-dm-raid kernel-module-snd-soc-cs42l51 perl-module-math-bigfloat perl-module-encode--pm harfbuzz kernel-module-videobuf-vmalloc kernel-module-lkkbd dbus-glib perl-module-extutils-mm kernel-module-pcf50633-adc kernel-module-cachefiles kernel-module-nf-conntrack-ipv6 kernel-module-twl4030-madc kernel-module-p54common kernel-module-arpt-mangle kernel-module-wlags49-h25-cs kernel-module-xcbc kernel-module-rtc-ds3232 kernel-module-rc-gotview7135 kernel-module-tps65010 kernel-module-w83793 kernel-module-xt-conntrack matchbox-session-sato kernel-module-algif-hash kernel-module-parport-ax88796 kernel-module-libcrc32c kernel-module-ip-vs-pe-sip kernel-module-i2c-parport-light perl-module-encode-kr kernel-module-xt-set ltp kernel-module-w1-ds2423 perl-modules kernel-module-smc911x kernel-module-nf-nat-irc perl-module-mro kernel-module-wm831x-bl kernel-module-speakup-acntsa python-json kernel-module-uss720 kernel-module-plip ca-certificates kernel-module-max8925-regulator perl-module-unicode-collate-locale-kk kernel-module-ccm kernel-module-snd-soc-wm2200 kernel-module-adp8860-bl kernel-module-rc-core kernel-module-lm78 libbz2 perl-module-perl5db kernel-module-tcm-loop perl-module-encode-configlocal-pm kernel-module-sdhci perl-module-pod-usage kernel-module-ibmpex kernel-module-speakup-bns kernel-module-rc-terratec-slim-2 kernel-module-n-r3964 kernel-module-rc-cinergy perl-module-unicode-collate-locale-af kernel-module-max6642 eglibc-localedata-translit-neutral kernel-module-ad7746 kernel-module-cx231xx-alsa kernel-module-mt9m111 kernel-module-rc-medion-x10 kernel-module-tmp421 perl-module-tie-hash perl-module-pod-perldoc kernel-module-libiscsi kernel-module-act-gact kernel-module-ip-queue kernel-module-n-tracerouter kernel-module-raid-class kernel-module-cdc-phonet kernel-module-videobuf-core kernel-module-blowfish-common kernel-module-ad7418 kernel-module-radio-i2c-si470x kernel-module-nls-euc-jp kernel-module-sch-tbf kernel-module-ip-tables perl-module-sys-syslog libe2p libxcalibrate perl-module-dbm-filter-int32 kernel-module-ad7780 libnl-route kernel-module-spcp8x5 kernel-module-ov2640 kernel-module-adt7411 perl-module-pod-perldoc-toman kernel-module-rtl8192c-common kernel-module-nfs kernel-module-stinger kernel-module-wm831x-isink perl-module-finddepth perl-module-locale-codes perl-module-net-ping perf kernel-module-snd-soc-wm5100 perl-module-posix-sigrt perl-module-io-compress-zip perl-module-term-cap kernel-module-cx2341x kernel-module-i2c-mux kernel-module-alphatrack perl-module-tainted xwininfo perl-module-tap-parser-result-comment perl-module-net-hostent kernel-module-gre piglit kernel-module-lirc-parallel perl-module-benchmark kernel-module-garp apmd perl-doc oprofile kernel-module-pc87360 perl-module-bigint kernel-module-stkwebcam gst-plugins-base-gio kernel-module-pps-parport kernel-module-gameport packagegroup-core-x11-sato perl-module-io-select kernel-module-hid-roccat-isku kernel-module-xt-secmark wayland libwrap glib-networking eglibc-localedata-translit-circle perl-module-dbm-filter-null kernel-module-ebt-snat kernel-module-spi-lm70llp perl-module-unicode-collate-locale-to kernel-module-soc-camera-platform kernel-module-ocfs2-dlm kernel-module-adis16204 kernel-module-iio-trig-periodic-rtc perl-module-autosplit kernel-module-leds-lt3593 kernel-module-dlm kernel-module-ti-usb-3410-5052 kernel-module-nls-cp862 kernel-module-snd-soc-wm8510 gnu-config eglibc-gconv-iso8859-15 kernel-module-lru-cache perl-module-cgi-carp kernel-module-old-belkin-sir perl-module-sys-hostname kernel-module-zl10353 kernel-module-rtc-rs5c348 kernel-module-hid-dr perl-module-pod-perldoc-totext eglibc-gconv perl-module-load libxxf86dga kernel-module-kobil-sct kernel-module-hid-magicmouse kernel-module-ipmi-msghandler packagegroup-core-boot kernel-module-smsmdtv kernel-module-dibx000-common kernel-module-stv6110x kernel-module-eeprom kernel-module-mtdchar kernel-module-camellia-generic cairo kernel-module-omaprpc kernel-module-em-nbyte libavahi-glib kernel-module-wm831x-on kernel-module-cramfs kernel-module-hid-chicony packagegroup-core-x11-sato-base kernel-module-max11801-ts kernel-module-hid-samsung python-pygobject kernel-module-snd-pcm-oss perl-module-encode-guess kernel-module-adt7462 kernel-module-ds2782-battery kernel-module-cdc-acm kernel-module-cx22702 qemuwrapper-cross kernel-module-pda-power kernel-module-ip-vs perl-module-digest-sha kernel-module-sierra-net kernel-module-autofs4 python-fcntl kernel-module-snd-soc-wm8983 kernel-module-rc-adstech-dvb-t-pci libssl kernel-module-hid-roccat-arvo perl-module-vmsish kernel-module-rc-winfast perl-module-locale-codes-script libsoup-2.4 kernel-module-snd-seq-midi kernel-module-ad7150 kernel-module-map-ram kernel-module-cma3000-d0x-i2c kernel-module-ip6t-eui64 kernel-module-sca3000 util-linux-fdisk perl-module-io-pipe perl-module-mime-quotedprint kernel-module-act-simple libowl kernel-module-ums-usbat kernel-module-rose kernel-module-rmd160 kernel-module-leds-regulator kernel-module-si21xx kernel-module-xt-comment kernel-module-hid-holtekff kernel-module-tcrypt pkgconfig perl-module-extutils-mm-dos kernel-module-xfrm6-mode-tunnel kernel-module-speakup-dtlk kernel-module-rtc-max8925 kernel-module-i2c-xiic kernel-module-ad9832 perl-module-file-spec-epoc xmodmap findutils kernel-module-dvb-usb-af9015 readline kernel-module-dvb-usb-vp702x kernel-module-ocfs2-stack-user kernel-module-gspca-sq930x kernel-module-libata python-logging kernel-module-zlib-deflate kernel-module-ebt-mark-m perl-module-encoding-warnings kernel-module-xt-tcpoptstrip kernel-module-dlci kernel-module-snd-soc-wm8988 kernel-module-romfs kernel-module-ade7754 libcidn kernel-module-hfc-usb perl-module-extutils-mm-any perl-module-pod-simple-htmlbatch settings-daemon kernel-module-dvb-usb-lmedm04 perl-module-cgi-util perl-module-compress-raw-bzip2 kernel-module-appletouch perl-module-charnames kernel-module-spectrum-cs perl-module-posix-sigaction kernel-module-adm1025 kernel-module-i2c-pca-platform perl-module-db kernel-module-nls-cp864 kernel-module-snd-soc-max9768 perl-module-tap-parser-yamlish-writer perl-module-package-constants kernel-module-tcp-probe file kernel-module-tuner-xc2028 kernel-module-tps6105x-regulator libcap kernel-module-uio cpp xrandr kernel-module-mos7720 kernel-module-max6875 perl-module-o kernel-module-act-csum libxcb kernel-module-ad5064 kernel-module-rt73usb kernel-module-g-midi kernel-module-softing-cs perl-module-unicode-collate-locale util-linux-libuuid kernel-module-rc-dib0700-rc5 kernel-module-snd-soc-wm8782 kernel-module-gspca-jeilinj kernel-module-ifb kernel-module-lm87 python-datetime kernel-module-snd-soc-cs42l73 kernel-module-cxacru kernel-module-dib7000p kernel-module-ip6t-rt kernel-module-rc-dntv-live-dvb-t openssh-sshd perl-module-carp kernel-module-imx074 kernel-module-sch-sfq kernel-module-gspca-konica kernel-module-snd-soc-rt5631 perl-module-abbrev kernel-module-snd-virmidi packagegroup-base-nfs kernel-module-radio-si4713 kernel-module-ip-set-hash-ipportnet kernel-module-dccp-ipv4 kernel-module-net1080 kernel-module-ad9910 kernel-module-adis16203 xkeyboard-config matchbox-session oh-puzzles kernel-module-usbhid kernel-module-s5h1420 kernel-module-crc-ccitt kernel-module-hid-roccat-pyra perl-module-net-protoent kernel-module-sch-hfsc kernel-module-x25 kernel-module-legousbtower kernel-module-metronomefb kernel-module-dvb-usb-dibusb-common kernel-module-rbd libacl kernel-module-target-core-iblock kernel-module-ip6table-raw kernel-module-nls-koi8-ru perl-module-text-tabs kernel-module-snd-soc-wm8750 kernel-module-ip6table-security kernel-module-snd-soc-ad73311 kernel-module-zl10039 kernel-module-seqiv kernel-module-l1oip perl-module-filecache kernel-module-baycom-ser-hdx kernel-module-ad7414 gdk-pixbuf-loader-gif libexif kernel-module-lm83 kernel-module-6pack kernel-module-lm75 perl-module-encode-tw eglibc-localedata-translit-cjk-compat kernel-module-configfs kernel-module-target-core-file systemtap kernel-module-ses kernel-module-dme1737 perl-module-io-uncompress-adapter-bunzip2 kernel-module-altera-stapl kernel-module-nls-iso8859-14 kernel-module-ums-alauda kernel-module-onenand perl-module-tie-substrhash kernel-module-ip-vs-sh kernel-module-ir-mce-kbd-decoder perl-module-tap-parser-scheduler-job gst-plugins-base-typefindfunctions kernel-module-rc-hauppauge kernel-module-ipt-reject perl-module-extutils-mksymlists kernel-module-xt-mac kernel-module-snd-soc-lm4857 perl-module-memoize-ndbm-file perl-module-ipc-sysv kernel-module-act-nat kernel-module-rc-tbs-nec perl-ptest kernel-module-ad5930 kernel-module-rt2800usb kernel-module-omap-udc packagegroup-base-usbgadget kernel-module-sil164 kernel-module-nf-conntrack kernel-module-w83792d kernel-module-cdc-eem perl-module-utf8 kernel-module-smsc75xx kernel-module-dvb-usb-az6027 perl-module-unicode-collate-locale-kl perl-module-test-builder kernel-module-snd-soc-wm8770 kernel-module-rc-kworld-pc150u kernel-module-nf-conntrack-amanda kernel-module-dvb-usb-dibusb-mc kernel-module-bnep kernel-module-nf-tproxy-core kernel-module-nls-cp855 kernel-module-gspca-stv0680 kernel-module-nf-conntrack-irc tiff kernel-module-iowarrior perl-module-user-pwent perl-module-extutils-parsexs perl-module-locale-maketext-gutsloader kernel-module-nls-iso8859-7 perl-module-io-poll kernel-module-dm-multipath kernel-module-g-nokia kernel-module-ir-sanyo-decoder kernel-module-dvb-usb-ce6230 libxcb-xfixes kernel-module-rtc-wm831x kernel-module-tm6000-dvb kernel-module-w1-ds2408 perl-module-io-zlib kernel-module-smsc libpciaccess perl-module-net-ftp-dataconn kernel-module-cfbimgblt kernel-module-isofs perl-module-ctime kernel-module-ssfdc elfutils kernel-module-smssdio perl-module-exporter-heavy perl-module-tap-parser-iteratorfactory less kernel-module-tda10071 kernel-module-input-polldev kernel-module-rc-pinnacle-color kernel-module-ili9320 perl-module-i18n-langtags-list kernel-module-mg-disk kernel-module-snd-soc-wm8978 pango perl-module-text-balanced kernel-module-xt-iprange openssl-conf kernel-module-af-alg kernel-module-symbolserial kernel-module-touchwin kernel-module-snd-soc-dfbmcs320 kernel-module-hdlc perl-module-next kernel-module-ati-remote2 kernel-module-gspca-gl860 kernel-module-rtc-ds1390 connman kernel-module-rmd256 kernel-module-rc-videomate-tv-pvr kernel-module-panel-taal kernel-module-deflate kernel-module-ad7879-i2c perl-module-attribute-handlers kernel-module-xt-led kernel-module-rc-digittrade kernel-module-rtc-stk17ta8 x11vnc kernel-module-hid-twinhan kernel-module-ipw busybox-syslog kernel-module-nls-cp860 kernel-module-hp4x ncurses-libmenuw kernel-module-ebt-ulog kernel-module-rpmsg-proto kernel-module-w1-therm kernel-module-videobuf2-vmalloc kernel-module-dib8000 kernel-module-snd-soc-adau1373 kernel-module-hid-picolcd kernel-module-netrom waffle kernel-module-ark3116 kernel-module-fcrypt perl-module-pod-perldoc-totk kernel-module-tda10048 kernel-module-rc-imon-pad kernel-module-xt-checksum kernel-module-max17042-battery libxxf86vm kernel-module-kxtj9 kernel-module-xc4000 kernel-module-rtc-m48t35 kernel-module-ad7879 kernel-module-stb6100 openssh-scp gst-plugins-good-id3demux kernel-module-gpio-pca953x kernel-module-generic-bl kernel-module-ipmi-devintf packagegroup-base-alsa kernel-module-max16065 kernel-module-nf-nat-proto-dccp kernel-module-raid1 python-multiprocessing kernel-module-bcm-wimax kernel-module-cfi-cmdset-0001 kernel-module-rc-pixelview-new kernel-module-async-tx kernel-module-ath9k-common kernel-module-ov772x kernel-module-leds-lp3944 kernel-module-nand-ids kernel-module-ppdev kernel-module-baycom-ser-fdx kernel-module-redboot util-linux-swaponoff kernel-module-scsi-transport-sas perl-module-app-prove-state-result kernel-module-lirc-sasem kernel-module-ums-isd200 kernel-module-leds-lp5521 perl-module-dbm-filter-utf8 perl-module-locale-codes-currency kernel-module-hid-apple kernel-module-snd-soc-wm8903 kernel-module-irda perl-module-file-spec kernel-module-scsi-transport-srp ldd kernel-module-tps6507x-ts perl-module-exporter kernel-module-isp1362-hcd kernel-module-snd-soc-cx20442 kernel-module-iptable-nat kernel-module-hid-roccat-koneplus kernel-module-adp5588-keys kernel-module-br2684 kernel-module-ov5642 kernel-module-dm-log-userspace kernel-module-cytherm perl-module-dumpvalue perl-module-file-find kernel-module-rc-avermedia-a16d kernel-module-acecad kernel-module-fujitsu-ts packagegroup-core-ssh-openssh kernel-module-gspca-conex perl-module-i18n-langtags-detect kernel-module-ip-set-hash-ip libsqlite3 kernel-module-radio-usb-si470x kernel-module-snd-soc-ad1836 kernel-module-rc-npgtech m4 kernel-module-cls-fw kernel-module-isl6423 kernel-module-hid-kensington perl-module-fastcwd kernel-module-rc-lirc libfakekey kernel-module-pcrypt perl-module-math-bigint-fastcalc python-textutils kernel-module-lm93 perl-module-file-basename kernel-module-usb-wwan gst-plugins-good-souphttpsrc kernel-module-uvesafb kernel-module-rc-msi-tvanywhere-plus kernel-module-psnap perl-module-tap-formatter-color perl-module-termcap kernel-module-hci-uart perl-module-pod-simple-pullparserstarttoken kernel-module-snd-soc-jz4740-codec perl-module-xsloader perl-module-extutils-constant kernel-module-scsi-dh-rdac kernel-module-cx231xx-dvb kernel-module-nf-nat-ftp eglibc kernel-module-lineage-pem perl-module-digest kernel-module-nls-cp737 kernel-module-pata-of-platform kernel-module-snd-soc-cs4270 perl-module-extutils-packlist alsa-utils-aplay perl-module-cgi-fast kernel-module-tmiofb kernel-module-qt1070 kernel-module-snd-soc-adav80x dbus kernel-module-mdio-bitbang perl-module-open2 kernel-module-ebt-mark pointercal perl-module-symbol kernel-module-baycom-par kernel-module-nf-conntrack-sane kernel-module-bcma kernel-module-snd-soc-l3 kernel-module-eql kernel-module-macvtap kernel-module-rndis-host kernel-module-rtc-max6900 matchbox-desktop kernel-module-ltc4261 kernel-module-dm9000 kernel-module-xt-mark kernel-module-bridge kernel-module-rc-ati-x10 libxmuu kernel-module-sch-dsmark kernel-module-gspca-spca561 kernel-module-dccp-probe perl-module-tap-parser-iterator-process kernel-module-rc-cinergy-1400 perl-module-thread-queue kernel-module-remoteproc perl-module-archive-tar-constant kernel-module-btrfs kernel-module-snd-soc-wm8991 kernel-module-lm70 kernel-module-ad525x-dpot-spi libgcc-dev perl-module-socket perl-module-extutils-cbuilder-platform-os2 kernel-module-libfc kernel-module-xt-multiport perl-module-extutils-cbuilder-platform-vms kernel-module-hid-uclogic kernel-module-nbd kernel-module-multipath kernel-module-ltc4245 kernel-module-hid-sjoy kernel-module-ad9850 kernel-module-inftl kernel-module-rc-kaiomy perl-module-tap-formatter-file kernel-module-ads1015 kernel-module-adis16130 kernel-module-isl6421 kernel-module-ir-rc5-sz-decoder kernel-module-p8023 kernel-module-wanrouter perl-module-english kernel-module-wl1273-core gaku kernel-module-rc-msi-tvanywhere kernel-module-map-absent libfm libext2fs perl-module-log-message perl-module-text-wrap libavahi-client kernel-module-squashfs perl-module-unicode-collate-locale-et kernel-module-nls-iso8859-2 kernel-module-xfs perl-module-encode-unicode-utf7 trace-cmd kernel-module-map-rom mpfr kernel-module-rds kernel-module-veth kernel-module-ad5933 kernel-module-g-webcam kernel-module-hid-cherry kernel-module-cy8ctmg110-ts kernel-module-i2c-ocores perl-module-extutils-cbuilder-platform-windows-gcc kernel-module-sm-ftl kernel-module-gspca-finepix kernel-module-cifs kernel-module-speakup-audptr kernel-module-snd-soc-tlv320aic3x kernel-module-adt7470 kernel-module-ip-set-bitmap-ipmac kernel-module-ircomm kernel-module-gpio-max730x kernel-module-snd-serial-u16550 kernel-module-vt1211 kernel-module-ad5791 kernel-module-speakup-soft kernel-module-ir-kbd-i2c kernel-module-em-meta kernel-module-hid-a4tech kernel-module-binfmt-aout openssh kernel-module-sermouse kernel-module-pktcdvd kernel-module-scsi-wait-scan kernel-module-i2c-gpio perl-module-pod-simple-search kernel-module-snd-rawmidi perl-module-compress-raw-zlib perl-module-file-spec-unix packagegroup-core-standalone-sdk-target libglade perl-module-term-ui-history kernel-module-sja1000 kernel-module-lec packagegroup-base-ipv6 perl-module-devel-innerpackage kernel-module-sr-mod kernel-module-spi-altera kernel-module-latch-addr-flash kernel-module-nftl perl-module-file-checktree kernel-base kernel-module-cx25840 kernel-module-hpfs libasound perl-module-b-xref kernel-module-xt-rateest kernel-module-ubifs kernel-module-w1-ds2431 kernel-module-snd-hwdep perl-module-unicode-collate-locale-om kernel-module-spidev kernel-module-videobuf2-memops kernel-module-xfrm6-mode-transport perl-module-test-more xtscal perl-module-b-deparse perl-module-tap-parser-result-version kernel-module-rc-flydvb kernel-module-sctp-probe kernel-module-ath kernel-module-qlogic-cs perl-module-pod-parselink kernel-module-tm6000 kernel-module-xt-ct kernel-module-udlfb packagegroup-core-qt-demoapps kernel-module-usblcd kernel-module-xt-hl perl-module-pod-text-color kernel-module-lm8323 kernel-module-max8649 perl-module-unicode-collate-locale-hy kernel-module-nls-utf8 perl-module-locale-maketext pango-module-basic-fc kernel-module-rtc-m48t86 libdrm-omap perl-module-encode-makefile-pl apm kernel-module-ksdazzle-sir kernel-module-lirc-ttusbir kernel-module-dvb-usb-dw2102 kernel-module-ums-realtek gdk-pixbuf-loader-xpm kernel-module-i2c-diolan-u2c kernel-module-snd-soc-twl4030 kernel-module-max7359-keypad kernel-module-io-edgeport kernel-module-pca954x kernel-module-cfspi-slave kernel-module-hid-ntrig kernel-module-snd-soc-sgtl5000 kernel-module-max8903-charger kernel-module-iptable-raw kernel-module-ad5398 libxext perl-module-math-bigint-calcemu kernel-module-pata-platform perl-module-unicode-collate-cjk-gb2312 kernel-module-snd-vx-lib kernel-module-ip6t-ipv6header kernel-module-bma150 kernel-module-speakup-apollo kernel-module-funsoft kernel-module-i2400m-sdio kernel-module-rc-iodata-bctv7e kernel-module-xfrm-ipcomp diffstat kernel-module-can-bcm kernel-module-snd-dummy kernel-module-ad9834 kernel-module-panel-tpo-td043mtea1 lrzsz perl-module-pod-simple-pullparsertexttoken kernel-module-hid-emsff kernel-module-isight-firmware libxml-parser-perl kernel-module-ir-lirc-codec gst-plugins-base-volume kernel-module-iptable-security kernel-module-rc-pixelview-002t perl-module-tie-hash-namedcapture kernel-module-xt-nflog kernel-module-gspca-t613 kernel-module-ad5504 kernel-module-rc-pinnacle-grey perl-module-net-netrc kernel-module-adt7410 kernel-module-asus-oled kernel-module-generic perl-module-feature perl-module-json-pp-boolean kernel-module-nls-iso8859-13 kernel-module-wl12xx perl-module-pod-simple-html tslib-tests kernel-module-xt-string packagegroup-base-bluetooth kernel-module-gl520sm perl-module-hash-util perl-module-encode kernel-module-gluebi perl-module-b-showlex kernel-module-tgr192 kernel-module-ads7871 kernel-module-lirc-dev kernel-module-orinoco kernel-module-ad525x-dpot kernel-module-f71805f kernel-module-block2mtd kernel-module-88pm860x-bl perl-module-cgi-push perl-module-subs kernel-module-leds-pca955x perl-module-shellwords kernel-module-snd-soc-wm8580 kernel-module-nf-nat-amanda kernel-module-ks8851-mll kernel-module-nls-cp874 kernel-module-twl6040-vibra kernel-module-xt-notrack kernel-module-smc91c92-cs kernel-module-wm8350-regulator kernel-module-ds1wm perl-module-cwd python-re kernel-module-speakup kernel-module-powermate busybox perl-module-net-ftp gdbm perl-module-pod-simple-dumpastext kernel-module-tm6000-alsa kernel-module-videobuf2-dma-contig kernel-module-gspca-ov519 kernel-module-sidewinder kernel-module-pn-pep kernel-module-gpio-pcf857x perl-module-extutils-mm-os2 perl-module-encode-encoding perl-module-file-spec-mac kernel-module-ring-sw perl-module-unicode-collate libgstpbutils-0.10 kernel-module-g-zero xz kernel-module-cfg80211 kernel-module-tuner-types kernel-module-xt-tee kernel-module-w35und kernel-module-ad7476 babeltrace kernel-module-da903x-bl kernel-module-isp1704-charger kernel-module-cypress-cy7c63 kernel-module-xt-recent mini-x-session xf86-input-evdev kernel-module-ebt-ip6 kernel-module-snd-soc-wm9081 kernel-module-de600 kernel-module-iwmc3200wifi kernel-module-rc-nebula ccache perl-module-encode-symbol kernel-module-gspca-pac207 kernel-module-as5011 kernel-module-rtc-bq32k perl-module-env perl-module-app-cpan ncurses-libncurses kernel-module-clearpad-tm1217 kernel-module-async-raid6-recov tcl kernel-module-videobuf2-core kernel-module-ebtables python-codecs perl-module-digest-file kernel-module-rc-behold kernel-module-dvb-usb kernel-module-rtc-r9701 kernel-module-rxkad kernel-module-gspca-vicam kernel-module-rtc-rx8025 kernel-module-dvb-usb-technisat-usb2 perl-module-extutils-constant-base kernel-module-ab8500-ponkey kernel-module-xt-pkttype kernel-module-wlcore openssl kernel-module-pwc perl-module-extutils-mm-win32 gst-plugins-base-ogg perl-module-thread perl-module-math-bigint-trace kernel-module-rtc-cmos perl-module-io-socket util-linux-losetup perl-module-perlio-via kernel-module-dvb-usb-digitv perl-module-extutils-mm-uwin dbus-wait busybox-hwclock kernel-vmlinux kernel-module-nls-cp1251 kernel-module-vitesse kernel-module-synclink-cs kernel-module-zlib kernel-module-libertas-tf packagegroup-core-x11-utils fstests kernel-module-adp8870-bl kernel-module-ir-rc5-decoder perl-module-encode-mime-name kernel-module-doc2001plus perl-module-timelocal perl-module-io-uncompress-adapter-inflate kernel-module-usb8xxx kernel-module-cfi-cmdset-0002 shared-mime-info strace perl-module-extutils-cbuilder-platform-aix kernel-module-p54spi kernel-module-quota-tree kernel-module-aoe kernel-module-uio-pdrv perl-module-tap-parser-iterator-stream perl-module-tie-array kernel-module-max17040-battery kernel-module-ip-set-bitmap-ip kernel-module-pcmciamtd perl-module-opcode kernel-module-seed libgcrypt kernel-module-ad525x-dpot-i2c kernel-module-gspca-etoms kernel-module-snd-soc-wm8523 perl-module-tap-parser-yamlish-reader kernel-module-rc-avermedia-rm-ks perl-module-extutils-cbuilder-platform-darwin perl-module-tap-parser-aggregator kernel-module-rds-tcp gst-plugins-good-wavparse kernel-module-rc-budget-ci-old kernel-module-rc-kworld-plus-tv-analog kernel-module-ade7758 kernel-module-zio kernel-module-rtc-msm6242 kernel-module-ade7854 kernel-module-sch-ingress kernel-module-teles-cs perl-module-encode-kr-2022-kr kernel-module-aha152x-cs kernel-module-usb-debug kernel-module-ip-set xset kernel-module-sctp perl-module-utf8-heavy kernel-module-twl4030-pwrbutton kernel-module-stv0299 libqtnetwork4 kernel-module-dib0090 kernel-module-tcp-scalable kernel-module-g-ffs kernel-module-max1111 xcb-util kernel-module-wimax kernel-module-ldusb kernel-module-dib3000mb perl-module-overloading kernel-module-rc-streamzap perl-module-loaded kernel-module-leds-da903x kernel-module-ah4 perl-module-ipc-open2 kernel-module-gspca-stk014 kernel-module-i2400m openssh-keygen kernel-module-ltc4215 perl-module-blib perl-module-extutils-testlib kernel-module-osdblk qt4-plugin-imageformat-gif kernel-module-xt-owner kernel-module-spaceorb kernel-module-gspca-mars perl-module-tap-parser-source perl-module-tap-parser-result kernel-module-8390 kernel-module-drbd kernel-module-platform-lcd perl-module-b-lint-debug kernel-module-ad5686 kernel-module-snd-mts64 kernel-module-snd-soc-wm8955 kernel-module-nf-conntrack-broadcast kernel-module-rtc-max6902 perl-module-extutils-mm-beos perl-module-corelist kernel-module-nls-cp1255 kernel-module-tekram-sir kernel-module-ipip kernel-module-snd-soc-wm8974 util-linux-cfdisk perl-module-test kernel-module-hid-petalynx kernel-module-ov6650 bash kernel-module-cxd2820r kernel-module-stv6110 libglapi kernel-module-hid-multitouch kernel-module-88pm860x-onkey kernel-module-xz-dec-test kernel-module-lirc-sir kernel-module-target-core-mod kernel-module-nf-nat-proto-gre kernel-module-gspca-xirlink-cit kernel-module-tmp102 kernel-module-nls-cp850 kernel-module-gspca-pac7311 kernel-module-econet kernel-module-emc2103 kernel-module-cx24116 kernel-module-apds9802als kernel-module-mdc800 kernel-module-mdio-gpio kernel-module-virtual perl-module-unicode-collate-locale-ar perl-module-encode-ebcdic kernel-module-iptable-mangle kernel-module-hid-microsoft kernel-module-mct-u232 perl-module-b-debug automake kernel-module-walkera0701 kernel-module-ad7298 libogg kernel-module-echo kernel-module-max1363 kernel-module-dm-mirror kernel-module-xt-ecn kernel-module-adm1031 kernel-module-atm kernel-module-dvb-usb-dibusb-mb kernel-module-w83791d kernel-module-gpio-keys-polled kernel-module-tranzport kernel-module-test-power kernel-module-rc-eztv kernel-module-dm-delay perl-module-file-globmapper kernel-module-opencores-kbd kernel-module-ansi-cprng gdk-pixbuf kernel-module-snd-seq-dummy perl-module-unicode-collate-locale-se update-rc.d kernel-module-w83627ehf perl-module-cgi-apache kernel-module-gpio-addr-flash perl-module-encode-jp-jis7 kernel-module-xilinx-uartps wpa-supplicant-cli kernel-module-rc-twinhan1027 libegl-mesa kernel-module-nls-koi8-u kernel-module-bcm203x kernel-module-nf-conntrack-ftp perl-module-tap-parser-scheduler-spinner libx11-xcb libqtcore4 kernel-module-radio-wl1273 kernel-module-zhenhua perl-module-memoize-sdbm-file kernel-module-ks8842 kernel-module-radio-tea5764 kernel-module-stmpe-ts ncurses-libpanelw kernel-module-snd-soc-wm8804 kernel-module-wire kernel-module-mk712 kernel-module-nf-conntrack-snmp xvideo-tests kernel-module-snd-soc-max98095 kernel-module-tmp401 connman-client perl-module-carp-heavy kernel-module-ip-vs-nq kernel-module-sch-choke kernel-module-ad799x libavahi-common kernel-module-lapb kernel-module-adis16240 perl-misc kernel-module-safe-serial kernel-module-ums-cypress kernel-module-i2c-simtec perl-module-devel-selfstubber kernel-module-irnet perl-module-storable perl-module-cgi-switch kernel-module-md4 kernel-module-rt2x00lib kernel-module-w83795 kernel-module-ch7006 libsysfs kernel-module-snd-soc-spdif kernel-module-pcwd-usb kernel-module-rtc-test kernel-module-rtc-ds1374 kernel-module-bh1770glc kernel-module-rfkill-regulator kernel-module-snd-soc-ssm2602 kernel-module-dvb-usb-nova-t-usb2 kernel-module-adis16060 perl-module-scalar-util-pp kernel-module-rfd-ftl kernel-module-g-multi perl-module-tap-parser-utils perl-module-extutils-cbuilder-platform-dec-osf kernel-module-nf-nat perl-module-pod-parser kernel-module-ad5360 xuser-account kernel-module-snd-pdaudiocf xserver-xorg kernel-module-ad7314 kernel-module-w1-smem kernel-module-isdn util-linux-sfdisk kernel-module-snd-soc-alc5623 kernel-module-gspca-benq kernel-module-algif-skcipher kernel-module-nf-nat-h323 perl-module-unicode-ucd kernel-module-pptp kernel-module-ray-cs bzip2 perl-module-ipc-semaphore kernel-module-snd-seq-midi-event kernel-module-snd-soc-tlv320aic26 kernel-module-gspca-spca500 kernel-module-rtc-ab8500 perl-module-newgetopt perl-module-autodie-exception-system perl-module-tap-parser-scheduler kernel-module-altera-ps2 kernel-module-xor libqtsvg4 perl-module-extutils-liblist kernel-module-keyspan-remote libapm kernel-module-snd-aloop kernel-module-inexio kernel-module-saa7115 kernel-module-airo kernel-module-llc kernel-module-authencesn kernel-module-sl811-cs kernel-module-gspca-ov534-9 packagegroup-base perl-module-log-message-handlers perl-module-pod-simple-pullparser kernel-module-wm831x-ldo perl-module-extutils-miniperl kernel-module-mt9t031 packagegroup-core-x11-base neard qt4-plugin-imageformat-jpeg kernel-module-w83l786ng kernel-module-rc-encore-enltv-fm53 kernel-module-isp1760 kernel-module-rtc-pcf2123 kernel-module-xt-socket kernel-module-ipt-redirect perl-module-tap-parser-multiplexer kernel-module-omap-rpmsg-resmgr kernel-module-at24 kernel-module-btwilink kernel-module-dvb-usb-a800 perl-module-app-prove-state-result-test perl-module-lib packagegroup-base-wifi kernel-module-pvrusb2 perl-module-pod-simple-rtf kernel-module-cdc-ncm kernel-module-mtdblock-ro kernel-module-snd-seq kernel-module-ppp-deflate kernel-module-leds-gpio kernel-module-rc-flyvideo perl-module-pod-plaintext kernel-module-synaptics-i2c-rmi4 perl-module-dumpvar kernel-module-vgg2432a4 perl-module-extutils-mm-cygwin kernel-module-scsi-debug kernel-module-hid-roccat-common perl-module-time-gmtime kernel-module-snd-soc-wm8400 kernel-module-hanwang kernel-module-batman-adv perl-module-tap-parser-iterator perl-module-selectsaver perl-module-math-complex libdmx kernel-module-gpio-keys kernel-module-c-can-platform kernel-module-rtc-ds1742 kernel-module-dm-queue-length kernel-module-omap-rdaemon kernel-module-snd-soc-ak4104 perl-module-math-bigint perl-module-pod-simple-pullparsertoken perl-module-pod-simple-progress kernel-module-rc-tivo kernel-module-airo-cs kernel-module-qcaux kernel-module-ad7192 kernel-module-nls-cp861 perl-module-search-dict perl-module-compress-zlib kernel-module-xusbatm gst-plugins-base-ximagesink kernel-module-smsc47m192 kernel-module-docecc kernel-module-tcp-illinois kernel-module-ebt-log xserver-nodm-init kernel-module-ipt-netmap gdk-pixbuf-loader-png libnss-mdns kernel-module-c67x00 tcl-lib perl-module-unicode-collate-locale-az kernel-module-rtc-pcf8563 kernel-module-em-cmp kernel-module-ip6t-mh kernel-module-rc-pv951 kernel-module-de620 alsa-conf-base kernel-module-ipmi-si perl-module-tie-stdhandle gst-plugins-base-vorbis kernel-module-b2c2-flexcop-usb slang kernel-module-usbtest kernel-module-smsc47b397 perl-module-app-prove kernel-module-hid-waltop kernel-module-saa7706h kernel-module-lightning kernel-module-i2c-taos-evm libdaemon kernel-module-ums-jumpshot kernel-module-snd-soc-tlv320aic23 kernel-module-dvb-usb-friio kexec kernel-module-9p fontconfig-utils kernel-module-ade7759 kernel-module-rtc-ds1553 kernel-module-wm8775 kernel-module-ip-set-hash-ipport kernel-module-caif-serial util-linux-mcookie kernel-module-hid-speedlink kernel-module-g-hid perl-module-parent perl-module-object-accessor perl-module-tap-parser-sourcehandler perl-module-extutils-command kernel-module-rio500 perl-module-time-piece kernel-module-caif kernel-module-phonedev kernel-module-mt352 kernel-module-max8925-bl kernel-module-b44 kernel-module-lrw kernel-module-speakup-ltlk perl-module-list-util-xs kernel-module-snd-soc-tpa6130a2 kernel-module-idmouse kernel-module-yealink kernel-module-raid6-pq kernel-module-snd-soc-cs4271 python-netserver kernel-module-w1-ds2433 kernel-module-snd-seq-device kernel-module-ip-vs-wrr kernel-module-bpqether kernel-module-xt-time kernel-module-tcp-lp kernel-module-xfrm4-mode-tunnel kernel-module-lcd kernel-module-wacom libmpc kernel-module-hid-cypress kernel-module-kl5kusb105 libcrypto perl-module-file-spec-functions perl-module-io-compress-deflate perl-module-inc-latest-private kernel-module-ipt-ecn kernel-module-cyberjack kernel-module-tcp-vegas kernel-module-doc2001 kernel-module-pwm-bl kernel-module-rc-trekstor kernel-module-nls-cp775 kernel-module-reed-solomon kernel-module-nls-cp857 libnewt kernel-module-fm-drv eglibc-localedata-translit-wide kernel-module-lm63 kernel-module-ip-vs-rr perl-module-locale-maketext-guts libss kernel-module-rj54n1cb0c kernel-module-bcm5974 kernel-module-pcf50633-gpio perl-module-net-servent perl-module-unicode-collate-locale-ru perl-module-test-builder-tester-color perl-module-stat perl-module-encode-encoder perl-module-pod-perldoc-tortf kernel-module-ems-usb kernel-module-max3100 matchbox-terminal kernel-module-gspca-nw80x kernel-module-rc-pinnacle-pctv-hd kernel-module-l2tp-ppp kernel-module-ds3000 kernel-module-can-dev kernel-module-redrat3 kernel-module-psmouse kernel-module-iptable-filter kernel-module-snd-soc-88pm860x kernel-module-ext2 kernel-module-mxl5005s cpp-symlinks perl-module-unicode-collate-locale-yo kernel-module-orinoco-cs kernel-module-nls-cp865 kernel-module-stowaway kernel-module-em-text kernel-module-sierra blktrace perl-module-io-compress-adapter-deflate kernel-module-ad714x-i2c kernel-module-siemens-mpi kernel-module-xt-classify kernel-module-nand-ecc kernel-module-pwm-beeper perl-module-file-spec-cygwin libdrm eglibc-localedata-translit-fraction kernel-module-pata-arasan-cf kernel-module-rfcomm kernel-module-xt-dccp kernel-module-snd-soc-wm8731 kernel-module-pcmcia kernel-module-xt-state perl-module-getopt kernel-module-act-police kernel-module-adi perl-module-io-seekable perl-module-io-compress-base eglibc-dbg kernel-module-da903x kernel-module-gpio-max732x gtk+ kernel-module-at76c50x-usb kernel-module-xfrm6-tunnel kernel-module-rtc-x1205 kernel-module-speakup-spkout kernel-module-litelink-sir kernel-module-hid-ortek kernel-module-ip-set-hash-netport kernel-module-gspca-sunplus kernel-module-isl6271a-regulator kernel-module-rc-terratec-cinergy-xs perl-module-tap-parser-result-plan libudev kernel-module-cdrom kernel-module-ad7606 kernel-module-hdlc-raw-eth kernel-module-slcan libgstinterfaces-0.10 perl-module-unicode-collate-locale-zh-gb perl-module-i18n-collate perl-module-autouse libxsettings-client perl-module-filetest kernel-module-nls-iso8859-3 kernel-module-isp116x-hcd kernel-module-appletalk kernel-module-tcm-fc sudo util-linux-mount kernel-module-uio-pdrv-genirq perl-module-extutils-command-mm kernel-module-snd-soc-ads117x rgb kernel-module-ste10xp kernel-module-evbug kernel-module-pcmcia-rsrc kernel-module-chipreg kernel-module-rmd128 libvorbis kernel-module-ipaq kernel-module-ipcomp kernel-module-snd-soc-wl1273 kernel-module-rc-winfast-usbii-deluxe kernel-module-scsi-tgt psplash kernel-module-whiteheat kernel-module-nls-iso8859-15 kernel-module-wm8400-core perl-module-memoize-storable udev-extraconf perl-module-test-simple kernel-module-joydev kernel-module-gf2k kernel-module-spaceball kernel-module-adis16080 kernel-module-rc-asus-pc39 kernel-module-digi-acceleport kernel-module-omap-remoteproc perl-module-pod-simple-linksection kernel-module-sparse-keymap kernel-module-catc kernel-module-arptable-filter kernel-module-w83781d perl-module-devel-ppport eglibc-gconv-cp1252 kernel-module-udf libcroco kernel-module-stb6000 kernel-module-ebt-arpreply e2fsprogs kernel-module-isdnhdlc kernel-module-pcf50633 kernel-module-esp4 kernel-module-dsbr100 kernel-module-oxu210hp-hcd kernel-module-nf-nat-sip perl-module-unicode-collate-locale-tn kernel-module-hampshire kernel-module-hdlc-x25 e2fsprogs-mke2fs kernel-module-dvb-pll kernel-module-spi-bitbang kernel-module-magellan libnl-nf perl-module-io-uncompress-anyuncompress ncurses-terminfo-base kernel-module-ch kernel-module-xt-devgroup kernel-module-iuu-phoenix kernel-module-ks959-sir kernel-module-raw kernel-module-xt-tcpmss kernel-module-pcf50633-charger kernel-module-dvb-usb-dtv5100 perl-module-unicode-collate-locale-sl libasound-module-bluez kernel-module-hdlc-fr tslib kernel-module-rc-manli perl-module-tap-formatter-base kernel-module-ipt-clusterip kernel-module-g760a perl-module-io-compress-adapter-bzip2 kernel-module-rc-digitalnow-tinytwin kernel-module-ltv350qv kernel-module-gspca-sonixj perl-module-test-builder-tester libgettextlib kernel-module-gspca-zc3xx kernel-module-em-u32 kernel-module-g-file-storage shutdown-desktop kernel-module-af-rxrpc perl-module-tap-formatter-console-session kernel-module-xt-policy kernel-module-snd-mpu401 kernel-module-act200l-sir alsa-utils-alsactl kernel-module-asc7621 kernel-module-target-core-pscsi kernel-module-jfs kernel-module-bfusb kernel-module-ushc perl-module-file-stat kernel-module-snd-ua101 formfactor kernel-module-snd-soc-pcm3008 alsa-utils-amixer ofono-tests kernel-module-rtc-em3027 kernel-module-tda826x kernel-module-em28xx kernel-module-tea kernel-module-wp512 kernel-module-max2165 kernel-module-rc-msi-digivox-ii kernel-module-aiptek perl-module-pod-simple-xmloutstream kernel-module-pcf50633-backlight kernel-module-rc-pixelview kernel-module-snd-mtpav kernel-module-rpmsg-omx kernel-module-hidp kernel-module-hid-zpff kernel-module-adm1026 perl-module-unicode-collate-locale-cy kernel-module-tps6105x kernel-module-twl4030-vibra kernel-module-max1668 kernel-module-pcf8574-keypad kernel-module-esi-sir sysvinit kernel-module-tda1004x python-dbus xhost kernel-module-smsdvb kernel-module-xpad kernel-module-88pm860x-ts kernel-module-nf-conntrack-ipv4 kernel-module-rc-msi-digivox-iii kernel-module-snd-soc-tlv320dac33 kernel-module-crc-itu-t perl-module-devel-peek perl-module-tap-parser-sourcehandler-perl kernel-module-ocfs2-stackglue perl-module-hash-util-fieldhash kernel-module-snd-usb-audio expat perl-module-tap-object kernel-module-nf-defrag-ipv6 kernel-module-atbm8830 kernel-module-sch5636 kernel-module-af-802154 kernel-module-bmp085 kernel-module-misdn-dsp kernel-module-ufs perl-module-tie-memoize kernel-module-rc-purpletv kernel-module-rc-tevii-nec qt4-plugin-imageformat-tiff kernel-module-mt20xx x11perf kernel-module-b2c2-flexcop perl-module-extutils-cbuilder-base libnl-cli perl-module-test-builder-module shadow-securetty perl-module-math-trig kernel-module-libosd kernel-module-rtc-max8998 kernel-module-act-mirred kernel-module-md-mod kernel-module-bq27x00-battery menu-cache kernel-module-gadgetfs kernel-module-salsa20-generic perl-module-xs-typemap packagegroup-base-nfc kernel-module-rc-videomate-m1f kernel-module-lg-vl600 kernel-module-gspca-main kernel-module-xt-limit kernel-module-mwifiex-sdio kernel-module-cm109 kernel-module-serpent-generic kernel-module-stv0900 perl-module-extutils-constant-proxysubs kernel-module-usbtouchscreen kernel-module-tcp-highspeed kernel-module-9pnet kernel-module-p8022 kernel-module-xt-connlimit kernel-module-speakup-acntpc perl-module-unicode-collate-locale-zh-strk kernel-module-act-skbedit kernel-module-ip-set-hash-ipportip pixman perl-module-pod-simple-blackbox libgbm kernel-module-ircomm-tty perl-module-re kernel-module-qinfo-probe kernel-module-ghash-generic kernel-module-vcan kernel-module-act-ipt kernel-module-cls-rsvp gst-plugins-good-flac kernel-module-lnbp21 kernel-module-smsc47m1 kernel-module-sch-teql apt kernel-module-sunrpc kernel-module-gpio-vbus perl-module-ipc-open3 matchbox-config-gtk kernel-module-bsd-comp kernel-module-fdomain-cs kernel-module-tca6416-keypad kernel-module-xt-connmark python-subprocess kernel-module-lgdt330x perl-module-safe kernel-module-grip kernel-module-tda9887 connman-gnome kernel-module-stb0899 kernel-module-ad7793 kernel-module-ip-set-bitmap-port kernel-module-usbsevseg kernel-module-nfnetlink kernel-module-gspca-sq905c perl-module-io-socket-inet perl-module-unicode-collate-cjk-stroke util-linux perl-module-i18n-langinfo perl-module-pod-perldoc-baseto perl-module-mime-base64 gst-meta-video kernel-module-xt-nfqueue kernel-module-iio-trig-gpio kernel-module-llc2 kernel-module-jc42 kernel-module-lms283gf05 kernel-module-ad2s90 perl-module-extutils-mm-win95 kernel-module-gen-probe eglibc-extra-nss kernel-module-osst eglibc-localedata-translit-narrow kernel-module-ebt-ip kernel-module-ceph netbase perl-module-pod-perldoc-tochecker kernel-module-qsemi kernel-module-moto-modem kernel-module-pppoe perl-module-extutils-mm-macos perl-module-extutils-mm-unix kernel-module-twidjoy kernel-module-async-pq libxcb-render kernel-module-cpia2 kernel-module-nfs-acl kernel-module-jedec-probe kernel-module-leds-dac124s085 kernel-module-btmrvl-sdio kernel-module-qlogicfas408 kernel-module-lm92 usbutils kernel-module-ebt-nflog kernel-module-ftdi-sio kernel-module-sir-dev kernel-module-cast5 gst-plugins-base-theora perl-module-extutils-cbuilder-platform-windows-msvc kernel-module-adt7310 kernel-module-exofs perl-module-pod-simple-debug perl-module-list-util connman-tests busybox-udhcpc kernel-module-axnet-cs kernel-module-rc-avermedia-dvbt kernel-module-vmac kernel-module-atxp1 kernel-module-hid-wiimote perl-module-unicode-collate-locale-eo libxv kernel-module-tsc2007 kernel-module-rc-anysee kernel-module-rtc-m41t80 kernel-module-gl518sm kernel-module-mtdoops kernel-module-dccp kernel-module-cls-tcindex gst-plugins-base-audioresample perl-module-memoize packagegroup-distro-base kernel-module-ad9852 perl-module-unicode-collate-locale-nso perl-module-unicore zlib libcomerr kernel-module-s2255drv kernel-module-dvb-usb-cxusb kernel-module-tda10023 perl-module-text-soundex libqtopengl4 kernel-module-gpio-mc33880 kernel-module-ab3100-otp kernel-module-ppp-async kernel-module-dvb-usb-au6610 kernel-module-ums-freecom perl-module-math-bigfloat-trace kernel-module-ip6t-ah kernel-module-int51x1 fotowall kernel-module-lapbether perl-module-term-readline kernel-module-xt-hashlimit kernel-module-adt7316 kernel-module-gpio-fan perl-module-autoloader kernel-module-lgs8gxx kernel-module-b43 python-netclient kernel-module-sst25l perl-module-tap-parser-result-test perl-module-pod-text-overstrike perl-module-term-complete mesa-demos kernel-module-ip-vs-sed kernel-module-atmtcp perl-module-io-compress-adapter-identity kernel-module-gpio-max7300 kernel-module-irtty-sir libxau kernel-module-qnx4 perl-module-extutils-makemaker-yaml matchbox-wm kernel-module-i2c-stub kernel-module-grip-mp kernel-module-stv0288 kernel-module-zd1211rw kernel-module-newtonkbd perl-module-unicode-collate-locale-sv python-mmap kernel-module-nxt6000 kernel-module-ipddp kernel-module-cpu-notifier-error-inject libqtxml4 libxfixes kernel-module-avma1-cs kernel-module-pppoatm perl-module-sdbm perl-module-extutils-mm-vms kernel-module-dn-rtmsg kernel-module-adxl34x-i2c kernel-module-i2c-tiny-usb kernel-module-isdn-bsdcomp kernel-module-interact perl-module-http-tiny kernel-module-poseidon kernel-module-cls-basic libpython2 gst-plugins-good-autodetect kernel-module-pcmcia-core kernel-module-dvb-usb-vp7045 perl-module-filter-simple kernel-module-f75375s libglu perl-module-deprecate kernel-module-cdc-subset libsegfault kernel-module-hid-gyration kernel-module-adxrs450 kernel-module-nop-usb-xceiv kernel-module-ipmi-poweroff kernel-module-ade7753 kernel-module-pps-ldisc perl-module-unicode-collate-locale-ca kernel-module-raid6test libgles2-mesa kernel-module-gpio-mcp23s08 perl-module-bignum kernel-module-libertas-tf-usb kernel-module-rtc-ds1511 kernel-module-ads7828 kernel-module-gl620a kernel-module-lpddr-cmds kernel-module-lm95245 kernel-module-ti-dac7512 kernel-module-mpr121-touchkey kernel-module-rtc-pcf50633 kernel-module-snd-soc-ak4671 kernel-module-ip-vs-wlc kernel-module-w1-ds2760 kernel-modules perl-module-tap-parser-resultfactory perl-module-extutils-mm-vos kernel-module-test-kstrtox kernel-module-pcf50633-input kernel-module-rc-it913x-v2 perl-module-pod-simple-textcontent kernel-module-dvb-as102 gst-plugins-good-matroska rpcbind perl-module-unicode-collate-cjk-pinyin kernel-module-msp3400 perl-module-extutils-mm-qnx perl-module-math-bigrat kernel-module-nf-conntrack-tftp kernel-module-wm831x-ts kernel-module-pegasus kernel-module-dm-round-robin perl-module-cgi kernel-module-carl9170 perl-module-locale-language kernel-module-industrialio kernel-module-altera-uart kernel-module-g-ether libxtst eglibc-mtrace perl-module-pod-latex kernel-module-hid-pl perl-module-test-harness kernel-module-tcp-westwood perl-module-fatal kernel-module-rc-kworld-315u kernel-module-twl4030-charger util-linux-umount libkmod hicolor-icon-theme kernel-module-gspca-sn9c2028 matchbox-keyboard-im kernel-module-twofish-generic kernel-module-alauda kernel-module-libfcoe libxdamage kernel-module-sit kernel-module-nmclan-cs kernel-module-nvram kernel-module-cx82310-eth kernel-module-snd-soc-wm-hubs perl-module-unicode-collate-locale-fo kernel-module-ath9k perl-module-file-dosglob kernel-module-xfrm4-mode-transport alsa-states kernel-module-ocfs2-dlmfs g++ kernel-module-nf-conntrack-netlink kmod perl-module-encode-unicode kernel-module-hfs kernel-module-aircable kernel-module-max8952 packagegroup-core-x11-sato-games kernel-module-wacom-w8001 psplash-default kernel-module-nand-bch kernel-module-mtouch perl-module-perlio kernel-module-vub300 kernel-module-speakup-dummy kernel-module-xt-addrtype diffutils perl-module-pod-simple-xhtml kernel-module-nf-conntrack-proto-gre kernel-module-snd-mixer-oss kernel-module-hdlc-cisco kernel-module-hid-kye kernel-module-rc-pixelview-mk12 kernel-module-snd-soc-wm8990 perl-module-xs-apitest kernel-module-hid-belkin kernel-module-da9034-ts shadow perl-module-pod-inputobjects kernel-module-snd-soc-alc5632 librsvg kernel-module-panel perl-module-extutils-constant-xs perl-module-pod-simple-simpletree kernel-module-reiserfs perl-module-unicode-normalize kernel-module-af9013 kernel-module-capidrv perl-module-unicode-collate-cjk-big5 autoconf kernel-module-stir4200 kernel-module-ebt-dnat sato-icon-theme kernel-module-joydump kernel-module-snd-soc-wm8711 kernel-module-w1-gpio libflac perl-module-extutils-constant-utils kernel-module-g-ncm kernel-module-arp-tables matchbox-theme-sato kernel-module-pps-core kernel-module-omninet kernel-module-mcs7780 kernel-module-ums-onetouch kernel-module-sysv kernel-module-rc-dib0700-nec perl-module-bytes-heavy sato-screenshot kernel-module-lis3lv02d-i2c gst-plugins-base-decodebin2 libxres kernel-module-turbografx kernel-module-tda10086 kernel-module-gpio-max7301 kernel-module-cls-rsvp6 kernel-module-pcf8591 kernel-module-mac80211 kernel-module-s6e63m0 kernel-module-hid-zydacron perl-module-errno kernel-image kernel-module-xt-sctp kernel-module-sdio-uart kernel-module-iscsi-boot-sysfs kernel-module-stv090x libgsttag-0.10 kernel-module-adm9240 kernel-module-gf128mul packagegroup-core-tools-testapps kernel-module-videobuf-dma-contig eglibc-gconv-iso8859-1 libxrender eglibc-localedata-iso14651-t1-common kernel-module-cma3000-d0x kernel-module-w90p910-ts kernel-module-rc-terratec-slim kernel-module-esp6 coreutils perl-module-digest-md5 kernel-module-tdo24m kernel-module-sunkbd kernel-module-8021q perl-module-time-tm e2fsprogs-e2fsck perl-module-unicode-collate-locale-sw kernel-module-ah6 kernel-module-isl29018 kernel-module-adis16209 libowl-av perl-module-unicode-collate-locale-es kernel-module-oprofile perl-module-unicode-collate-locale-da kernel-module-dss1-divert kernel-module-snd-soc-wm8994 kernel-module-gigaset kernel-module-leds-lp5523 kernel-module-mcp2120-sir kernel-module-wlags49-h2-cs kernel-module-iforce kernel-module-rc-gadmei-rm008z kernel-module-snd-soc-wm8995 kernel-module-rc-powercolor-real-angel startup-notification kernel-module-ramoops kernel-module-itd1000 python-io kernel-module-rc-avertv-303 kernel-module-timblogiw kernel-module-ftdi-elan kernel-module-nf-conntrack-proto-sctp perl-module-version-requirements update-alternatives-opkg kernel-module-snd-soc-uda134x kernel-module-virtio-rpmsg-bus perl-module-encode-mime-header-iso-2022-jp kernel-module-rtc-rv3029c2 kernel-module-ltc4151 openssh-ssh perl-module-fields kernel-module-rc-avermedia-m733a-rm-k6 kernel-module-crc7 perl-module-file-copy libcurl packagegroup-base-zeroconf kernel-module-auth-rpcgss kernel-module-apds990x kernel-module-i2400m-usb perl-module-i18n-langtags kernel-module-cuse perl-module-tie-file python-shell kernel-module-phonet kernel-module-tps6507x-regulator kernel-module-ocfs2 kernel-module-mtd-blkdevs perl-module-extutils-mm-aix kernel-module-ethoc kernel-module-snd-soc-ak4642 kernel-module-microtek kernel-module-a3d kernel-module-emi62 perl-module-inc-latest perl-module-io-compress-gzip-constants perl-module-locale-constants libnl kernel-module-usbtmc perl-module-perlio-encoding kernel-module-rc-imon-mce kernel-module-rc-avermedia-cardbus tcf-agent perl-module-io-uncompress-unzip perl-module-pod-functions kernel-module-cls-flow kernel-module-ntfs eglibc-dev perl-module-extutils-cbuilder kernel-module-serqt-usb2 kernel-module-ebt-limit kernel-module-snd-soc-wm8727 perl-module-unicode-collate-locale-ig kernel-module-mtd perl-module-locale kernel-module-rtc-v3020 kernel-module-actisys-sir perl-module-tap-parser-sourcehandler-rawtap kernel-module-serport kernel-module-ip6t-reject kernel-module-hid-ezkey kernel-module-mc44s803 perl-module-extutils-installed kernel-module-hisax-st5481 kernel-module-xfrm4-tunnel packagegroup-base-extended kernel-module-dvb-usb-m920x kernel-module-ps2mult kernel-module-snd-soc-da7210 perl-module-autodie-hints kernel-module-nsp-cs kernel-module-cs53l32a kernel-module-ipt-ulog kernel-module-hid-axff patch kernel-module-xt-audit perl-module-memoize-anydbm-file kernel-module-ibmaem kernel-module-enclosure perl-module-io-uncompress-bunzip2 kernel-module-adxl34x kernel-module-hid-tmff kernel-module-xirc2ps-cs kernel-module-gpio-mouse kernel-module-da9030-battery kernel-module-usb-gigaset perl-module-net-netent kernel-module-libceph perl-module-validate kernel-module-lm90 wireless-tools kernel-module-sch-sfb kernel-module-rc-avermedia kernel-module-xfrm4-mode-beet kernel-module-clip kernel-module-rc-encore-enltv kernel-module-lm73 kernel-module-mt9v022 perl-module-archive-extract perl-module-io-dir kernel-module-leds-pca9532 perl-module-pod-simple-text kernel-module-rc-it913x-v1 kernel-module-b43legacy kernel-module-snd-soc-ak4641 kernel-module-minix kernel-module-nls-cp949 kernel-module-rtc-isl1208 lttng-tools kernel-module-ocfs2-stack-o2cb vte-termcap kernel-module-snd-soc-tlv320aic32x4 kernel-module-speedtch kernel-module-ubi kernel-module-rc-genius-tvgo-a11mce kernel-module-garmin-gps kernel-module-cx24123 kernel-module-lm80 kernel-module-ipcomp6 kernel-module-xfrm6-mode-beet kernel-module-usbvision kernel-module-speakup-dectlk kernel-module-nfsd kernel-module-dvb-usb-anysee kernel-module-ipheth perl-module-unicode-collate-locale-lt perl-module-parse-cpan-meta kernel-module-xt-cluster perl-module-locale-codes-language kernel-module-dvb-usb-af9005 kernel-module-snd-soc-wm9090 perl-module-time-localtime perl-module-getopts libgomp gettext kernel-module-pcf50633-regulator kernel-module-macvlan kernel-module-btuart-cs kernel-module-tuner-simple perl-module-dbm-filter-compress alsa-state perl-module-unicode-collate-locale-fr kernel-module-xt-helper kernel-module-rc-rc6-mce kernel-module-rc-nec-terratec-cinergy-xs kernel-module-rtlwifi kernel-module-elsa-cs perl-module-unicode-collate-locale-sk kernel-module-nfnetlink-queue eglibc-localedata-iso14651-t1 kernel-module-w83627hf kernel-module-hdlc-raw kernel-module-xfrm6-mode-ro kernel-module-nf-conntrack-pptp kernel-module-lirc-igorplugusb kernel-module-snd-usbmidi-lib kernel-module-spi-dw perl-module-digest-base kernel-module-hso kernel-module-rtc-ds1286 kernel-module-bch oprofileui-server kernel-module-ipmi-watchdog kernel-module-adm1021 kernel-module-lzo kernel-module-rc-total-media-in-hand kernel-module-rpcsec-gss-krb5 kernel-module-rtc-m41t93 packagegroup-core-x11-xserver kernel-module-ts-bm perl-module-if kernel-module-dvb-usb-ec168 perl-module-unicode-collate-locale-pl kernel-module-wm8400-regulator kernel-module-m88rs2000 kernel-module-ueagle-atm perl-module-extutils-cbuilder-platform-unix kernel-module-pcbc kernel-module-kafs kernel-module-p54usb kernel-module-snd-soc-wm8737 perl-module-bigfloat kernel-module-parport perl-module-unicode-collate-locale-ro perl-module-pod-text-termcap perl-module-cgi-cookie kernel-module-xt-dscp libxfont perl-module-integer perl-module-findbin kernel-module-gcm kernel-module-st xf86-video-omap kernel-module-nxt200x python-xml perl-module-net-smtp kernel-module-mma8450 gcc kernel-module-tcp-bic kernel-module-ebtable-broute kernel-module-rtc-88pm860x kernel-module-stmmac run-postinsts hdparm kernel-module-rc-dm1105-nec kernel-module-raid0 perl-module-filter-util-call kernel-module-sl811-hcd avahi-daemon kernel-module-can dbus-lib kernel-module-can-raw kernel-module-vsxxxaa kernel-module-a8293 kernel-module-snd-soc-wm8993 perl-module-flush perl-module-extutils-embed kernel-module-cobra kernel-module-stp kernel-module-snd-soc-wm2000 perl-module-pod-simple-checker kernel-module-ir-nec-decoder kernel-module-ad714x connman-tools kernel-module-mkiss kernel-module-lm95241 perl-module-json-pp kernel-module-adt7475 perl-module-pod-simple kernel-module-nf-conntrack-proto-dccp packagegroup-core-x11-sato-apps perl-module-unicode-collate-locale-uk kernel-module-rmd320 perl-module-cgi-pretty perl-module-math-bigint-calc linux-libc-headers-dev kernel-module-sch-gred kernel-module-ad5446 kernel-module-xt-osf kernel-module-pc87427 perl-module-filehandle kernel-module-ath9k-hw kernel-module-lp3971 kernel-module-softing kernel-module-gspca-tv8532 kernel-module-altera-jtaguart kernel-module-rc-evga-indtube kernel-module-lirc-serial perl-module-io-uncompress-anyinflate kernel-module-gunze kernel-module-snd-soc-wm8985 kernel-module-mtdram kernel-module-timeriomem-rng kernel-module-gspca-spca501 perl-module-io-compress-zip-constants perl-module-encode-gsm0338 kernel-module-vt6656-stage kernel-module-girbil-sir kernel-module-sch-prio perl-module-encode-cjkconstants perl-module-unicode-collate-locale-sq kernel-dev kernel-module-ebt-802-3 util-linux-readprofile gst-meta-base perl-module-file-temp kernel-module-qcserial kernel-module-snd-soc-max98088 perl-module-open3 kernel-module-snd-soc-wm8728 kernel-module-ft1000 kernel-module-lis3lv02d kernel-module-tda8290 glib-2.0 kernel-module-mt9m001 kernel-module-xt-physdev kernel-module-rc-azurewave-ad-tu700 perl-module-pod-select kernel-module-gspca-spca505 kernel-module-mwifiex kernel-module-ser-gigaset kernel-module-timbuart kernel-module-sm7xx kernel-module-uvcvideo matchbox-desktop-sato xserver-xorg-module-exa kernel-module-rts5139 kernel-module-nandsim kernel-module-lm77 sysprof kernel-module-snd-soc-wm8741 perl-module-encode-byte kernel-module-ip6t-frag gst-meta-x11-base kernel-module-ds2490 kernel-module-bluecard-cs gmp kernel-module-mt9v011 kernel-module-stv0297 kernel-module-anubis kernel-module-ds2760-battery perl-module-extutils-my kernel-module-gspca-m5602 perl-module-dotsh kernel-module-nf-nat-proto-udplite kernel-module-tps6524x-regulator perl-module-tap-parser perl-module-unicode-collate-locale-ja kernel-module-pppox perl-module-net-cmd kernel-module-m25p80 perl-module-config-extensions kernel-module-nls-iso8859-5 kernel-module-hid-sunplus kernel-module-ov9740 kernel-module-ebt-pkttype perl-module-threads gstreamer kernel-module-ebt-arp kernel-module-mac80211-hwsim kernel-module-scsi-dh-emc kernel-module-ad7877 kernel-module-dvb-usb-gl861 kernel-module-cp210x perl-module-pod-find kernel-module-rc-technisat-usb2 kernel-module-wlcore-sdio kernel-module-bh1780gli perl-module-pod-html distcc kernel-module-cdc-ether kernel-module-nf-conntrack-proto-udplite kernel-module-gpio-74x164 python-core kernel-module-btmrvl perl-module-tap-formatter-session kernel-module-gspca-ov534 kernel-module-rc-videomate-s350 kernel-module-lgdt3305 kernel-module-dm-zero kernel-module-ftl kernel-module-ip-vs-ftp kernel-module-l2tp-core libxcomposite eglibc-gconv-ibm850 perl-module-gdbm-file kernel-module-matrix-keypad kernel-module-xt-connbytes xprop kernel-module-nf-conntrack-h323 kernel-module-snd-hrtimer perl-module-unicode-collate-locale-de-phone e2fsprogs-badblocks kernel-module-snd-seq-virmidi kernel-module-sja1000-platform kernel-module-adv7180 libusb-compat kernel-module-rtc-pcf8583 mtdev kernel-module-cfbfillrect libstdc++-dev kernel-module-hid-topseed kernel-module-tps6586x-regulator kernel-module-at25 kernel-module-hisax perl-module-syslog kernel-module-pl2303 kernel-module-gspca-spca1528 perl-module-pod-perldoc-tonroff sysfsutils perl-module-extutils-install kernel-module-wm831x-dcdc perl-module-io-file kernel-module-plat-ram kernel-module-mceusb kernel-module-rtc-ds1305 kernel-module-amc6821 kernel-module-usbserial perl-module-hostname perl-module-time-hires kernel-module-ip6-queue perl-module-app-prove-state kernel-module-speakup-decext atk kernel-module-map-funcs perl-module-shell libasm kernel-module-guillemot perl-module-log-message-config kernel-module-gspca-kinect kernel-module-sht21 perl-module-metadata kernel-module-nls-koi8-r perl-module-time-local kernel-module-sch-cbq kernel-module-quatech-usb2 kernel-module-ch341 udev kernel-module-crypto-null kernel-module-diskonchip kernel-module-snd-soc-wm1250-ev1 kernel-module-mt312 perl-module-base kernel-module-spi-butterfly kernel-module-lm85 kernel-module-mcs-touchkey perl-module-tap-parser-grammar kernel-module-dvb-usb-gp8psk kernel-module-hfcsusb kernel-module-nfnetlink-log kernel-module-mos7840 perl-module-params-check kernel-module-spi-gpio perl-module-net-ftp-a kernel-module-ipwireless kernel-module-max8997 xserver-xf86-config kernel-module-hid-wacom kernel-module-rc-alink-dtu-m kernel-module-ax25 perl-module-extutils-manifest kernel-module-snd-soc-wm8900 kernel-module-isl29020 kernel-module-ip-gre kernel-module-nf-nat-tftp fontconfig perl-module-cpan kernel-module-zr364xx kernel-module-rtc-m41t94 kernel-module-si4713-i2c kernel-module-xt-connsecmark kernel-module-blowfish-generic kernel-module-nls-cp936 kernel-module-osd kernel-module-soc-camera kernel-module-scsi-transport-spi perl-module-getcwd modutils-initscripts kernel-module-snd-soc-wm8940 kernel-module-snd-soc-ak4535 kernel-module-dm9601 openssh-sftp-server jpeg perl-module-pod-simple-dumpasxml wpa-supplicant-passphrase intltool kernel-module-ledtrig-default-on kernel-module-ipt-masquerade ncurses-libncursesw perl-module-file-spec-os2 perl-module-extutils-cbuilder-platform-windows-bcc kernel-module-dtl1-cs perl-module-unicode-collate-locale-vi perl-module-perl-ostype kernel-module-sym53c500-cs kernel-module-xt-tproxy kernel-module-adfs kernel-module-rc-avermedia-m135a perl-module-b perl-module-file-fetch wpa-supplicant kernel-module-cts kernel-module-ad7291 kernel-module-hostap-cs kernel-module-quota-v2 perl-module-unicode-collate-locale-cs perl-module-file-spec-win32 gdbserver kernel-module-hid libx11 perl-module-io-uncompress-adapter-identity kernel-module-max8998 kernel-module-ieee802154 kernel-module-dm-crypt kernel-module-tsl2563 perl-module-tap-parser-sourcehandler-handle kernel-module-docprobe perl-module-extutils-mm-nw5 kernel-module-gspca-spca508 kernel-module-ebtable-nat perl-module-io kernel-module-ip6-tables kernel-module-gspca-sonixb perl-module-unicode-collate-locale-fil kernel-module-i2c-smbus perl-module-io-handle kernel-module-rtc-ds1672 kernel-module-rt2500usb kernel-module-physmap kernel-module-enc28j60 python-ctypes kernel-module-gspca-sq905 kernel-module-gtco kernel-module-rc-lme2510 kernel-module-tda18212 kernel-module-rpmsg-resmgr kernel-module-adp5520-keys perl-module-sort kernel-module-tw9910 kernel-module-ip-vs-lblcr kernel-module-nf-nat-pptp libgcc kernel-module-adis16400 perl-module-unicode-collate-locale-mt libxi kernel-module-mtdblock perl-module-io-compress-zlib-constants kernel-module-ip-set-hash-net util-linux-libmount kernel-module-cfi-cmdset-0020 kernel-module-rtl8150 perl-module-extutils-liblist-kid perl-module-ipc-cmd perl-module-overload kernel-module-nls-cp852 kernel-module-tmdc kernel-module-xc5000 kernel-module-tuner packagegroup-base-usbhost kernel-module-nf-defrag-ipv4 kernel-module-sch-mqprio perl-module-assert kernel-module-hdpvr perl-module-encode-jp libgettextsrc perl-module-dbm-filter kernel-module-trancevibrator perl-module-perlio-via-quotedprint perl-module-pod-parseutils kernel-module-ff-memless kernel-module-drxk kernel-module-ip-set-list-set perl-module-locale-currency kernel-module-smsusb dpkg gettext-dev kernel-module-rc-snapstream-firefly kernel-module-raid10 perl-module-unicode-collate-locale-is kernel-module-libertas-sdio kernel-module-gspca-mr97310a kernel-module-hid-gaff kernel-module-freevxfs kernel-module-rtl8187 kernel-module-tsc2005 kernel-module-efs kernel-module-befs kernel-module-r8712u kernel-module-ledtrig-gpio kernel-module-libore perl-module-dynaloader perl-module-selfloader kernel-module-snd-usb-caiaq perl-module-pod-simple-transcode perl-module-tap-parser-result-bailout alsa-utils-alsamixer kernel-module-dvb-usb-dib0700 libxcb-shm perl-module-io-uncompress-gunzip kernel-module-mip6 kernel-module-g-audio kernel-module-ad7152 kernel-module-sha512-generic pcmanfm libfontenc perl-module-memoize-expire kernel-module-ics932s401 kernel-module-hid-lcpower perl-module-io-compress-rawdeflate perl-module-unicode-collate-locale-hu kernel-module-hid-roccat-kovaplus liburcu kernel-module-cfbcopyarea kernel-module-s5h1411 libgstaudio-0.10 kernel-module-snd-portman2x4 perl-module-config-git kernel-module-tda18271 perl-module-locale-country kernel-module-sch56xx-common ofono kernel-module-yurex kernel-module-rc-loopback perl-module-term-ui libffi kernel-module-tda827x libgstriff-0.10 bluez4 kernel-module-rtc-rx8581 kernel-module-lirc-imon perl-module-net-time gst-plugins-base perl-module-data-dumper kernel-module-ad2s1200 kernel-module-sch-htb libnl-genl kernel-module-mcs5000-ts kernel-module-tps65910-regulator base-files kernel-module-xtkbd perl-module-unicode-collate-locale-ko kernel-module-nf-nat-snmp-basic kernel-module-tsl2550 kernel-module-l4f00242t03 kernel-module-3c574-cs kernel-module-hid-prodikeys kernel-module-ad5624r-spi kernel-module-quota-v1 python-elementtree kernel-module-prism2-usb kernel-module-xt-length ncurses-libtinfo kernel-module-xt-tcpudp perl-module-tap-parser-sourcehandler-executable kernel-module-mt9t112 kernel-module-mcp251x kernel-module-ipx libgpg-error kernel-module-hid-keytouch kernel-module-tsl2583 kernel-module-rc-tt-1500 kernel-module-kxsd9 kernel-module-dvb-usb-cinergyt2 kernel-module-cdc-wdm kernel-module-af-key libgomp-dev kernel-module-libertas-spi perl-module-universal xrestop kernel-module-ax88796 perl-module-unicode-collate-locale-wo kernel-module-em28xx-dvb perl-module-io-compress-base-common perl-lib blktool perl-module-file-glob kernel-module-bonding kernel-module-u132-hcd libxcb-dri2 kernel-module-linear perl-module-ops perl-module-pod-simple-tiedoutfh kernel-module-nls-cp1250 kernel-module-xts kernel-module-gfs2 perl-module-tap-harness perl-module-bytes libxdmcp perl-module-encode-mime-header kernel-module-sh-mobile-ceu-camera kernel-module-cast6 libxcb-shape kernel-module-ledtrig-backlight packagegroup-machine-base kernel-module-tda18271c2dd libqtgui4 kernel-module-rc-apac-viewcomp perl-module-find kernel-module-chnl-net perl-module-thread-semaphore perl-module-autodie perl-module-attributes python-pygobject-lib perl-module-anydbm-file kernel-module-navman kernel-module-rtl8192cu eglibc-utils kernel-module-ocfs2-nodemanager kernel-module-bfs kernel-module-timb-dma kernel-module-thmc50 libvte libxinerama kernel-module-hid-roccat-kone gst-plugins-base-xvimagesink perl-module-ipc-sharedmem kernel-module-onenand-sim kernel-module-snd-ak4117 perl-module-autodie-exception kernel-module-gspca-cpia1 matchbox-panel-2 kernel-module-ad9951 perl-module-tap-parser-result-yaml kernel-module-async-memcpy kernel-module-ums-datafab kernel-module-omapdce perl-module-unicode-collate-locale-ha kernel-module-scsi-dh-alua kernel-module-authenc kernel-module-nand kernel-module-hfc4s8s-l1 kernel-module-affs kernel-module-ums-karma kernel-module-rc-em-terratec kernel-module-dvb-core kernel-module-dvb-usb-umt-010 kernel-module-htc-pasic3 kernel-module-ad7816 kernel-module-khazad perl-module-extutils-mm-darwin perl-module-look kernel-module-kbtab kernel-module-irda-usb kernel-module-ir-sony-decoder kernel-module-irlan perl-module-bigrat perl-module-term-ansicolor perl-module-pod-simple-pullparserendtoken kernel-module-ip-vs-lc kernel-module-dynapro perl-module-encode-alias kernel-module-ssb kernel-module-sch-multiq kernel-module-hdlcdrv kernel-module-ebt-among perl-module-unicode-collate-locale-nn kernel-module-tveeprom kernel-module-atmel-cs kernel-module-iwmc3200top perl-module-io-uncompress-base kernel-module-ums-eneub6250 tslib-calibrate kernel-module-oti6858 kernel-module-hid-primax kernel-module-synaptics-i2c perl-module-unicode-collate-locale-zh kernel-module-wl3501-cs perl-module-pod-simple-transcodedumb kernel-module-ld9040 kernel-module-videobuf-dvb kernel-module-netconsole kernel-module-tcp-hybla kernel-module-ade7854-spi gconf kernel-module-g-dbgp kernel-module-ebt-stp kernel-module-3c589-cs kernel-module-g-cdc kernel-module-snd-soc-wm8960 kernel-module-snd-soc-wm8904 kernel-module-serio-raw kernel-module-cx24113 kernel-module-asix perl-module-diagnostics perl-module-time-seconds libxrandr kernel-module-ip6t-hbh kernel-module-smm665 util-linux-mkfs kernel-module-tea5767 kernel-module-rc-ati-tv-wonder-hd-600 kernel-module-hid-elecom perl-module-overload-numbers kernel-module-libertas udev-cache kernel-module-i2c-algo-pca kernel-module-raid456 kernel-module-speakup-decpc kernel-module-max1586 perl-module-extutils-cbuilder-platform-cygwin libdw kernel-module-esd-usb2 perl-module-user-grent kernel-module-db9 python-lang kernel-module-ncpfs kernel-module-ad7887 packagegroup-core-sdk kernel-module-ip6-tunnel kernel-module-sht15 kernel-module-smc91x kernel-module-ebtable-filter kernel-module-nls-cp950 kernel-module-isl29003 kernel-module-w83l785ts kernel-module-elo kernel-module-userspace-consumer perl-module-open tslib-conf libtasn1 packagegroup-core-tools-debug kernel-module-qt1010 kernel-module-tunnel6 kernel-module-jffs2 perl-module-net-pop3 kernel-module-phram xkbcomp kernel-module-dm-service-time perl-module-locale-script kernel-module-rt2x00usb perl perl-module-net-ftp-i make perl-module-cacheout kernel-module-hfsplus kernel-module-uas kernel-module-s921 kernel-module-hid-roccat kernel-module-cm4000-cs kernel-module-sedlbauer-cs kernel-module-ipt-ah kernel-module-tvp5150 perl-module-unicode-collate-locale-nb kernel-module-snd-soc-wm8776 kernel-module-leds-adp5520 perl-module-encode-cn-hz perl-module-perlio-scalar kernel-module-bpa10x kernel-module-twl4030-madc-hwmon kernel-module-nls-iso8859-9 kernel-module-spi-tle62x0 perl-module-unicode-collate-locale-tr perl-module-list-util-pp perl-module-pwd perl-module-devel-dprof perl-module-tie-scalar kernel-module-dccp-ipv6 kernel-module-sch-drr kernel-module-dvb-usb-dtt200u expat-dev kernel-module-lp3972 packagegroup-base-apm kernel-module-ntc-thermistor kernel-module-tipc kernel-module-rndis-wlan kernel-module-xt-quota kernel-module-max6650 kernel-module-ip-vs-lblc kernel-module-ir-usb kernel-module-tunnel4 gdk-pixbuf-loader-jpeg kernel-module-usbatm perl-module-net-ftp-l perl-module-tie-refhash kernel-module-eeprom-93cx6 kernel-module-opticon kernel-module-atmel kernel-module-touchit213 kernel-module-x-tables kernel-module-rt2800lib kernel-module-st1232 kernel-module-pcnet-cs x11-common kernel-module-gpio-i2cmux kernel-module-nls-iso8859-6 kernel-module-dnet kernel-module-adp5589-keys sysvinit-pidof kernel-module-rotary-encoder kernel-module-rc-proteus-2309 kernel-module-gspca-sn9c20x perl-module-file-compare kernel-module-btusb kernel-module-ma600-sir kernel-module-nls-cp932 kernel-module-ip6table-mangle perl-module-tap-formatter-console-parallelsession kernel-module-tef6862 kernel-module-cypress-m8 eglibc-localedata-translit-small liberation-fonts kernel-module-tda18218 g++-symlinks kernel-module-leds-lm3530 kernel-module-f71882fg packagegroup-core-buildessential kernel-module-ir-jvc-decoder perl-module-io-compress-gzip iptables libattr kernel-module-rc-real-audio-220-32-keys kernel-module-gspca-pac7302 perl-module-encoding kernel-module-parkbd kernel-module-empeg kernel-module-keyspan-pda perl-module-unicode-collate-locale-zh-big5 kernel-module-tcp-veno kernel-module-tps6507x packagegroup-base-3g kernel-module-ft1000-pcmcia perl-module-log-message-simple kernel-module-ad7879-spi perl-module-unicode-collate-locale-zh-pin kernel-module-mb86a20s perl-module-sdbm-file kernel-module-snd-mpu401-uart kernel-module-r8a66597-hcd kernel-module-ts-kmp kernel-module-pata-pcmcia perl-module-pod-checker xinit perl-module-archive-tar perl-module-tap-parser-result-pragma perl-module-text-parsewords python-crypt perl-module-net-domain kernel-module-vivi kernel-module-hid-monterey perl-module-encode-jp-h2z base-passwd kernel-module-libiscsi-tcp kernel-module-lp kernel-module-tcp-yeah kernel-module-soc-mediabus perl-module-io-socket-unix perl-module-version kernel-module-adm1029 kernel-module-max8925-onkey perl-module-tap-parser-iterator-array perl-module-b-terse kernel-module-nls-iso8859-4 kernel-module-emi26 perl-module-less perl-module-net-config libtirpc kernel-module-hwmon-vid kernel-module-xfrm-user kernel-module-ds1621 perl-module-getopt-long kernel-module-w1-bq27000 perl-module-cpanplus gst-plugins-base-playbin kernel-module-pca9541 perl-module-file-path kernel-module-snd-soc-wm8962 kernel-module-tps65023-regulator kernel-module-snd-soc-wm8350 kernel-module-speakup-txprt kernel-module-dm-log perl-module-net-ftp-e kernel-module-xt-idletimer perl-module-pod-perldoc-toxml kernel-module-drxd kernel-module-scsi-transport-iscsi kernel-module-rtc-bq4802 kernel-module-max1619 kernel-module-adxl34x-spi kernel-module-option perl-module-pod-text kernel-module-act-pedit kernel-module-cx231xx perl-module-memoize-expiretest kernel-module-hid-sony perl-module-threads-shared kernel-module-adp5520-bl kernel-module-xt-esp perl-module-io-compress-bzip2 libtool kernel-module-touchright kernel-module-scsi-transport-fc kernel-module-adis16220 kernel-module-cryptd kernel-module-analog libxxf86misc perl-module-tap-parser-result-unknown kernel-module-bt3c-cs kernel-module-max8997-charger gst-plugins-base-alsa kernel-module-atmel-mxt-ts kernel-module-rc-fusionhdtv-mce packagegroup-base-ext2 kernel-module-nf-conntrack-sip kernel-module-adis16260 kernel-module-memstick kernel-module-adutux kernel-module-iio-trig-sysfs kernel-module-ds2780-battery perl-module-io-uncompress-inflate kernel-module-ts-fsm kernel-module-xt-trace kernel-module-n-tracesink kernel-module-w1-ds2780 perl-module-encode-changes kernel-module-tea5761 kernel-module-ath3k kernel-module-faulty perl-module-io-compress-zlib-extra libaio kernel-module-lirc-zilog kernel-module-des-generic kernel-module-pktgen kernel-module-rtc-wm8350 kernel-module-sch-red kernel-module-belkin-sa kernel-module-rtc-s35390a kernel-module-capi kernel-module-keucr perl-module-getopt-std perl-module-archive-tar-file kernel-module-snd-soc-wm8996 perl-module-importenv perl-module-extutils-cbuilder-platform-windows kernel-module-l2tp-debugfs kernel-module-adis16201 eglibc-gconv-utf-16 kernel-module-snd-soc-max9877 perl-module-unicode-collate-locale-lv perl-module-unicode-collate-cjk-korean kernel-module-mt2266 perl-module-pluggable kernel-module-kaweth kernel-module-cm4040-cs kernel-module-bu21013-ts perl-module-b-concise kernel-module-dib7000m kernel-module-it87 perl-module-build kernel-module-zaurus freetype kernel-module-sch5627 kernel-module-omfs kernel-module-dvb-usb-opera kernel-module-g-serial perl-module-fcntl gst-plugins-base-videoscale kernel-module-omap-vout kernel-module-snd-soc-max9850 libsdl kernel-module-xt-u32 kernel-module-gspca-stv06xx kernel-module-lis3lv02d-spi kernel-module-penmount kernel-module-ath9k-htc kernel-module-mtd-dataflash perl-module-extutils-makemaker-config kernel-module-ctr kernel-module-sch-atm xauth kernel-module-usblp kernel-module-ade7854-i2c kernel-module-dvb-usb-af9005-remote kernel-module-mspro-block kernel-module-nls-ascii kernel-module-et61x251 perl-module-locale-maketext-simple kernel-module-realtek kernel-module-xt-ipvs kernel-module-kfifo-buf kernel-module-emc1403 python-readline kernel-module-kalmia perl-module-unicode-collate-locale-hr kernel-module-hci-vhci perl-module-net-nntp kernel-module-ds1682 kernel-module-appledisplay libsm kernel-module-usbled kernel-module-ec100 xdpyinfo kernel-module-mpoa kernel-module-dvb-usb-ttusb2 kernel-module-hid-logitech-dj kernel-module-lockd kernel-module-tcp-htcp initscripts kernel-module-snd-soc-ad193x kernel-module-slip perl-module-pod-man kernel-module-leds-bd2802 kernel-module-micrel kernel-module-ad714x-spi kernel-module-ums-sddr55 kernel-module-libsas kernel-module-output kernel-module-snd-soc-uda1380 gst-plugins-base-ffmpegcolorspace perl-module-sigtrap perl-module-pod-perldoc-topod perl-module-scalar-util perl-module-text-abbrev kernel-module-libertas-cs kernel-module-rtc-rs5c372 kernel-module-gpio-adp5520 perl-module-unicode-collate-cjk-jisx0208 perl-module-locale-codes-country kernel-module-crypto-user kernel-module-kingsun-sir libice kernel-module-plusb eglibc-localedata-translit-compat kernel-module-snd-vxpocket kernel-module-max8660 kernel-module-gamecon kernel-module-dm-snapshot kernel-module-snd-soc-sta32x libxcursor perl-module-tap-formatter-console libtheora kernel-module-rc-pctv-sedna kernel-module-cfi-util kernel-module-ssu100 kernel-module-dm-region-hash kernel-module-em28xx-alsa kernel-module-rc-norwood kernel-module-cfi-probe kernel-module-c-can perl-module-dirhandle perl-module-exceptions kernel-module-xt-cpu kernel-module-tpm-atmel kernel-module-io-ti kernel-module-caif-socket perl-module-complete kernel-module-gpio-charger kernel-module-imon kernel-module-rtc-ds1307 kernel-module-wm8994-regulator perl-module-posix kernel-module-cryptoloop kernel-module-xt-statistic packagegroup-core-eclipse-debug kernel-module-ums-sddr09 eglibc-localedata-i18n kernel-module-nls-cp869 initscripts-functions kernel-module-ds620 eglibc-localedata-translit-font kernel-module-max3107 kernel-module-cls-route perl-module-memoize-expirefile python-stringold perl-module-unicode-collate-locale-es-trad perl-module-tap-base kernel-module-sch-qfq liblzma kernel-module-rc-encore-enltv2 binutils kernel-module-ads7846 perl-module-unicode-collate-locale-fi eglibc-thread-db kernel-module-gspca-spca506 matchbox-keyboard kernel-module-rtc-rp5c01 kernel-module-mt2060 kernel-module-x25-asy kernel-module-dib0070 kernel-module-rtc-ds3234 kernel-module-speakup-keypc kernel-module-gator perl-module-extutils-mkbootstrap kernel-module-nf-nat-proto-sctp kernel-module-bcm3510 owl-video kernel-module-streamzap libgstvideo-0.10 libmatchbox kernel-module-rtc-isl12022 kernel-module-max6639 kernel-module-yam udev-utils kernel-module-rtc-fm3130 kernel-module-gspca-vc032x perl-module-io-uncompress-rawinflate kernel-module-gpio-adp5588 kernel-module-rc-behold-columbus kernel-module-spi-oc-tiny kernel-module-core usbutils-ids popt kernel-module-virtio gst-meta-audio libelf libxml2 perl-module-class-struct xcursor-transparent-theme kernel-module-ds2482 kernel-module-snd-soc-wm8753 libxft kernel-module-virtio-ring kernel-module-ir-rc6-decoder kernel-module-national kernel-module-mtdswap kernel-module-snd-soc-wm8961 libstdc++ python-threading kernel-module-doc2000 util-linux-libblkid ncurses-libformw perl-module-log-message-item python-math perl-module-constant kernel-module-nls-cp866 kernel-module-radio-mr800 kernel-module-ad2s1210 kernel-module-kernelcapi kernel-module-ix2505v kernel-module-keyspan kernel-module-hid-logitech kernel-module-adt7316-i2c kernel-module-ip-vs-dh kernel-module-warrior kernel-module-ks8851 perl-module-encode-cn kernel-module-g-printer kernel-module-slram kernel-module-i2c-parport perl-module-extutils-makemaker python-pickle kernel-module-sn9c102 gtk-theme-sato kernel-module-vivopay-serial kernel-module-scsi-dh-hp-sw kernel-module-rtc-m48t59 kernel-module-bas-gigaset perl-module-encode-readme kernel-module-s5h1409 gtk-sato-engine perl-module-tie-handle perl-module-tap-parser-sourcehandler-file kernel-module-bluetooth init-ifupdown kernel-module-thermal-sys libpcre kernel-module-ip6table-filter kernel-module-mxl5007t kernel-module-adcxx kernel-module-ledtrig-timer kernel-module-ebt-redirect kernel-module-dib3000mc perl-module-tap-formatter-file-session kernel-module-adt7316-spi kernel-module-twofish-common gst-plugins-good kernel-module-rpmsg-resmgr-common python-mime perl-module-encode-config kernel-module-ppp-mppe kernel-module-hdlc-ppp kernel-module-snd-soc-wm8971 libpng kernel-module-sm501fb leafpad perl-module-file-spec-vms kernel-module-ns558 perl-module-pod-escapes kernel-module-decnet kernel-module-sisusbvga kernel-module-btsdio kernel-module-ov9640 gcc-symlinks kernel-module-misdn-core kernel-module-broadsheetfb perl-module-ipc-msg kernel-module-iscsi-tcp kernel-module-toim3232-sir libxkbfile gst-plugins-good-avi kernel-module-s1d13xxxfb kernel-module-rc-dntv-live-dvbt-pro kernel-module-xt-realm libavahi-core kernel-module-ebt-vlan quicky lttng-ust gdb quilt perl-module-pod-perldoc-getoptsoo gst-plugins-base-decodebin perl-module-encode--t kernel-module-mcs7830 libusb1 perl-module-pod-simple-transcodesmart kernel-module-sdhci-pltfm kernel-module-max8998-charger kernel-module-zd1201 kernel-module-fmvj18x-cs kernel-module-nf-conntrack-netbios-ns kernel-module-line6usb kernel-module-nilfs2 kernel-module-sch-netem kernel-module-softdog libgl-mesa perl-module-dbm-filter-encode perl-module-pod-simple-htmllegacy gst-plugins-base-audioconvert kernel-module-nls-cp863 perl-module-unicode-collate-locale-haw kernel-module-dccp-diag kernel-module-ppp-synctty perl-module-pod-simple-methody kernel-module-visor kernel-module-hmc6352 "
DESCRIPTION = ""
