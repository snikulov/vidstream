require /home/snikulov/work/yocto/Daisy/poky/meta/recipes-sato/images/core-image-sato-sdk.bb
IMAGE_INSTALL = "perl-module-b-lint sysvinit-inittab matchbox-keyboard-applet libxcb-glx gnutls perl-module-math-bigfloat perl-module-encode--pm harfbuzz dbus-glib perl-module-extutils-mm matchbox-session-sato perl-module-encode-kr perl-modules perl-module-mro ca-certificates perl-module-unicode-collate-locale-kk libbz2 perl-module-perl5db perl-module-encode-configlocal-pm perl-module-pod-usage perl-module-unicode-collate-locale-af eglibc-localedata-translit-neutral perl-module-tie-hash perl-module-pod-perldoc kernel-module-ip-tables perl-module-sys-syslog libxcalibrate perl-module-dbm-filter-int32 libnl-route perl-module-pod-perldoc-toman perl-module-finddepth perl-module-locale-codes perl-module-net-ping perl-module-posix-sigrt perl-module-io-compress-zip perl-module-term-cap perl-module-tainted perl-module-tap-parser-result-comment perl-module-net-hostent perl-module-benchmark perl-doc perl-module-bigint gst-plugins-base-gio packagegroup-core-x11-sato perl-module-io-select libwrap glib-networking eglibc-localedata-translit-circle perl-module-dbm-filter-null perl-module-unicode-collate-locale-to perl-module-autosplit gnu-config eglibc-gconv-iso8859-15 perl-module-cgi-carp perl-module-sys-hostname perl-module-pod-perldoc-totext eglibc-gconv perl-module-load libxxf86dga packagegroup-core-boot cairo packagegroup-core-x11-sato-base perl-module-encode-guess qemuwrapper-cross perl-module-digest-sha libssl perl-module-vmsish perl-module-locale-codes-script libsoup-2.4 util-linux-fdisk perl-module-io-pipe perl-module-mime-quotedprint libowl pkgconfig perl-module-extutils-mm-dos perl-module-file-spec-epoc xmodmap findutils readline perl-module-encoding-warnings libcidn perl-module-extutils-mm-any perl-module-pod-simple-htmlbatch settings-daemon perl-module-cgi-util perl-module-compress-raw-bzip2 perl-module-charnames perl-module-posix-sigaction perl-module-db perl-module-tap-parser-yamlish-writer perl-module-package-constants file libcap cpp xrandr perl-module-o libxcb perl-module-unicode-collate-locale util-linux-libuuid openssh-sshd perl-module-carp perl-module-abbrev xkeyboard-config matchbox-session oh-puzzles perl-module-net-protoent perl-module-text-tabs perl-module-filecache gdk-pixbuf-loader-gif libexif perl-module-encode-tw eglibc-localedata-translit-cjk-compat perl-module-io-uncompress-adapter-bunzip2 perl-module-tie-substrhash perl-module-tap-parser-scheduler-job gst-plugins-base-typefindfunctions perl-module-extutils-mksymlists perl-module-memoize-ndbm-file perl-module-ipc-sysv perl-ptest kernel-module-nf-conntrack perl-module-utf8 perl-module-unicode-collate-locale-kl perl-module-test-builder tiff perl-module-user-pwent perl-module-extutils-parsexs perl-module-locale-maketext-gutsloader perl-module-io-poll perl-module-io-zlib libpciaccess perl-module-net-ftp-dataconn perl-module-ctime perl-module-exporter-heavy perl-module-tap-parser-iteratorfactory less perl-module-i18n-langtags-list pango perl-module-text-balanced openssl-conf perl-module-next connman perl-module-attribute-handlers x11vnc busybox-syslog perl-module-pod-perldoc-totk libxxf86vm openssh-scp gst-plugins-good-id3demux util-linux-swaponoff perl-module-app-prove-state-result perl-module-dbm-filter-utf8 perl-module-locale-codes-currency perl-module-file-spec ldd perl-module-exporter kernel-module-iptable-nat perl-module-dumpvalue perl-module-file-find packagegroup-core-ssh-openssh perl-module-i18n-langtags-detect libsqlite3 m4 perl-module-fastcwd libfakekey perl-module-math-bigint-fastcalc perl-module-file-basename gst-plugins-good-souphttpsrc perl-module-tap-formatter-color perl-module-termcap perl-module-pod-simple-pullparserstarttoken perl-module-xsloader perl-module-extutils-constant eglibc perl-module-digest perl-module-extutils-packlist perl-module-cgi-fast dbus perl-module-open2 pointercal perl-module-symbol matchbox-desktop libxmuu perl-module-tap-parser-iterator-process perl-module-thread-queue perl-module-archive-tar-constant libgcc-dev perl-module-socket perl-module-extutils-cbuilder-platform-os2 perl-module-extutils-cbuilder-platform-vms perl-module-tap-formatter-file perl-module-english gaku libfm perl-module-log-message perl-module-text-wrap libavahi-client perl-module-unicode-collate-locale-et perl-module-encode-unicode-utf7 mpfr perl-module-extutils-cbuilder-platform-windows-gcc openssh perl-module-pod-simple-search perl-module-compress-raw-zlib perl-module-file-spec-unix packagegroup-core-standalone-sdk-target perl-module-term-ui-history perl-module-devel-innerpackage perl-module-file-checktree kernel-base libasound perl-module-b-xref perl-module-unicode-collate-locale-om perl-module-test-more xtscal perl-module-b-deparse perl-module-tap-parser-result-version perl-module-pod-parselink packagegroup-core-qt-demoapps perl-module-pod-text-color perl-module-unicode-collate-locale-hy perl-module-locale-maketext pango-module-basic-fc libdrm-omap perl-module-encode-makefile-pl gdk-pixbuf-loader-xpm libxext perl-module-math-bigint-calcemu perl-module-unicode-collate-cjk-gb2312 diffstat perl-module-pod-simple-pullparsertexttoken libxml-parser-perl gst-plugins-base-volume perl-module-tie-hash-namedcapture perl-module-net-netrc perl-module-feature perl-module-json-pp-boolean perl-module-pod-simple-html perl-module-hash-util perl-module-encode perl-module-b-showlex perl-module-cgi-push perl-module-subs perl-module-shellwords perl-module-cwd busybox perl-module-net-ftp gdbm locale-base-en-gb perl-module-pod-simple-dumpastext perl-module-extutils-mm-os2 perl-module-encode-encoding perl-module-file-spec-mac perl-module-unicode-collate libgstpbutils-0.10 xz mini-x-session xf86-input-evdev ccache perl-module-encode-symbol perl-module-env perl-module-app-cpan ncurses-libncurses tcl perl-module-digest-file perl-module-extutils-constant-base perl-module-extutils-mm-win32 gst-plugins-base-ogg perl-module-thread perl-module-math-bigint-trace perl-module-io-socket util-linux-losetup perl-module-perlio-via perl-module-extutils-mm-uwin dbus-wait busybox-hwclock packagegroup-core-x11-utils perl-module-encode-mime-name perl-module-timelocal perl-module-io-uncompress-adapter-inflate shared-mime-info strace perl-module-extutils-cbuilder-platform-aix perl-module-tap-parser-iterator-stream perl-module-tie-array perl-module-opcode libgcrypt perl-module-tap-parser-yamlish-reader perl-module-extutils-cbuilder-platform-darwin perl-module-tap-parser-aggregator gst-plugins-good-wavparse perl-module-encode-kr-2022-kr xset perl-module-utf8-heavy libqtnetwork4 xcb-util perl-module-overloading perl-module-loaded perl-module-ipc-open2 openssh-keygen perl-module-blib perl-module-extutils-testlib qt4-plugin-imageformat-gif perl-module-tap-parser-source perl-module-tap-parser-result perl-module-b-lint-debug perl-module-extutils-mm-beos perl-module-corelist util-linux-cfdisk perl-module-test bash libglapi perl-module-unicode-collate-locale-ar perl-module-encode-ebcdic perl-module-b-debug automake libogg perl-module-file-globmapper gdk-pixbuf perl-module-unicode-collate-locale-se update-rc.d perl-module-cgi-apache perl-module-encode-jp-jis7 wpa-supplicant-cli perl-module-tap-parser-scheduler-spinner libx11-xcb libqtcore4 perl-module-memoize-sdbm-file perl-module-carp-heavy libavahi-common perl-misc perl-module-devel-selfstubber perl-module-storable perl-module-cgi-switch perl-module-scalar-util-pp perl-module-tap-parser-utils perl-module-extutils-cbuilder-platform-dec-osf kernel-module-nf-nat perl-module-pod-parser xuser-account xserver-xorg util-linux-sfdisk perl-module-unicode-ucd bzip2 perl-module-ipc-semaphore perl-module-newgetopt perl-module-autodie-exception-system perl-module-tap-parser-scheduler libqtsvg4 perl-module-extutils-liblist libapm perl-module-log-message-handlers perl-module-pod-simple-pullparser perl-module-extutils-miniperl locale-base-en-us packagegroup-core-x11-base qt4-plugin-imageformat-jpeg perl-module-tap-parser-multiplexer perl-module-app-prove-state-result-test perl-module-lib perl-module-pod-simple-rtf perl-module-pod-plaintext perl-module-dumpvar perl-module-extutils-mm-cygwin perl-module-time-gmtime perl-module-tap-parser-iterator perl-module-selectsaver perl-module-math-complex libdmx perl-module-math-bigint perl-module-pod-simple-pullparsertoken perl-module-pod-simple-progress perl-module-search-dict perl-module-compress-zlib gst-plugins-base-ximagesink xserver-nodm-init gdk-pixbuf-loader-png libnss-mdns tcl-lib perl-module-unicode-collate-locale-az alsa-conf-base perl-module-tie-stdhandle gst-plugins-base-vorbis perl-module-app-prove libdaemon fontconfig-utils util-linux-mcookie perl-module-parent perl-module-object-accessor perl-module-tap-parser-sourcehandler perl-module-extutils-command perl-module-time-piece perl-module-list-util-xs libmpc libcrypto perl-module-file-spec-functions perl-module-io-compress-deflate perl-module-inc-latest-private eglibc-localedata-translit-wide perl-module-locale-maketext-guts perl-module-net-servent perl-module-unicode-collate-locale-ru perl-module-test-builder-tester-color perl-module-stat perl-module-encode-encoder perl-module-pod-perldoc-tortf matchbox-terminal kernel-module-iptable-filter cpp-symlinks perl-module-unicode-collate-locale-yo perl-module-io-compress-adapter-deflate perl-module-file-spec-cygwin libdrm eglibc-localedata-translit-fraction perl-module-getopt perl-module-io-seekable perl-module-io-compress-base eglibc-dbg gtk+ perl-module-tap-parser-result-plan libudev libgstinterfaces-0.10 perl-module-unicode-collate-locale-zh-gb perl-module-i18n-collate perl-module-autouse libxsettings-client perl-module-filetest sudo util-linux-mount perl-module-extutils-command-mm rgb libvorbis psplash perl-module-memoize-storable udev-extraconf perl-module-test-simple perl-module-pod-simple-linksection perl-module-devel-ppport eglibc-gconv-cp1252 libcroco perl-module-unicode-collate-locale-tn libnl-nf perl-module-io-uncompress-anyuncompress ncurses-terminfo-base perl-module-unicode-collate-locale-sl tslib perl-module-tap-formatter-base perl-module-io-compress-adapter-bzip2 perl-module-test-builder-tester libgettextlib shutdown-desktop perl-module-tap-formatter-console-session perl-module-file-stat formfactor perl-module-pod-simple-xmloutstream perl-module-unicode-collate-locale-cy sysvinit xhost kernel-module-nf-conntrack-ipv4 perl-module-devel-peek perl-module-tap-parser-sourcehandler-perl perl-module-hash-util-fieldhash expat perl-module-tap-object perl-module-tie-memoize qt4-plugin-imageformat-tiff perl-module-extutils-cbuilder-base libnl-cli perl-module-test-builder-module shadow-securetty perl-module-math-trig menu-cache perl-module-xs-typemap perl-module-extutils-constant-proxysubs perl-module-unicode-collate-locale-zh-strk pixman perl-module-pod-simple-blackbox perl-module-re gst-plugins-good-flac apt perl-module-ipc-open3 matchbox-config-gtk perl-module-safe connman-gnome perl-module-io-socket-inet perl-module-unicode-collate-cjk-stroke util-linux perl-module-i18n-langinfo perl-module-pod-perldoc-baseto perl-module-mime-base64 gst-meta-video perl-module-extutils-mm-win95 eglibc-extra-nss eglibc-localedata-translit-narrow netbase perl-module-pod-perldoc-tochecker perl-module-extutils-mm-macos perl-module-extutils-mm-unix libxcb-render gst-plugins-base-theora perl-module-extutils-cbuilder-platform-windows-msvc perl-module-pod-simple-debug perl-module-list-util busybox-udhcpc perl-module-unicode-collate-locale-eo libxv gst-plugins-base-audioresample perl-module-memoize perl-module-unicode-collate-locale-nso perl-module-unicore zlib perl-module-text-soundex libqtopengl4 perl-module-math-bigfloat-trace fotowall perl-module-term-readline perl-module-autoloader perl-module-tap-parser-result-test perl-module-pod-text-overstrike perl-module-term-complete perl-module-io-compress-adapter-identity libxau perl-module-extutils-makemaker-yaml matchbox-wm perl-module-unicode-collate-locale-sv libqtxml4 libxfixes perl-module-sdbm perl-module-extutils-mm-vms perl-module-http-tiny gst-plugins-good-autodetect perl-module-filter-simple perl-module-deprecate libsegfault perl-module-unicode-collate-locale-ca perl-module-bignum perl-module-tap-parser-resultfactory perl-module-extutils-mm-vos perl-module-pod-simple-textcontent gst-plugins-good-matroska perl-module-unicode-collate-cjk-pinyin perl-module-extutils-mm-qnx perl-module-math-bigrat perl-module-cgi perl-module-locale-language libxtst eglibc-mtrace perl-module-pod-latex perl-module-test-harness perl-module-fatal util-linux-umount libkmod hicolor-icon-theme matchbox-keyboard-im libxdamage perl-module-unicode-collate-locale-fo perl-module-file-dosglob g++ perl-module-encode-unicode packagegroup-core-x11-sato-games psplash-default perl-module-perlio diffutils perl-module-pod-simple-xhtml perl-module-xs-apitest shadow perl-module-pod-inputobjects librsvg perl-module-extutils-constant-xs perl-module-pod-simple-simpletree perl-module-unicode-normalize perl-module-unicode-collate-cjk-big5 autoconf sato-icon-theme libflac perl-module-extutils-constant-utils matchbox-theme-sato perl-module-bytes-heavy sato-screenshot gst-plugins-base-decodebin2 perl-module-errno kernel-image libgsttag-0.10 eglibc-binary-localedata-en-us eglibc-gconv-iso8859-1 libxrender eglibc-localedata-iso14651-t1-common coreutils perl-module-digest-md5 perl-module-time-tm perl-module-unicode-collate-locale-sw libowl-av perl-module-unicode-collate-locale-es perl-module-unicode-collate-locale-da startup-notification perl-module-version-requirements update-alternatives-opkg perl-module-encode-mime-header-iso-2022-jp openssh-ssh perl-module-fields perl-module-file-copy libcurl perl-module-i18n-langtags perl-module-tie-file perl-module-extutils-mm-aix perl-module-inc-latest perl-module-io-compress-gzip-constants perl-module-locale-constants libnl perl-module-perlio-encoding tcf-agent perl-module-io-uncompress-unzip perl-module-pod-functions eglibc-dev perl-module-extutils-cbuilder perl-module-unicode-collate-locale-ig perl-module-locale perl-module-tap-parser-sourcehandler-rawtap perl-module-extutils-installed perl-module-autodie-hints patch perl-module-memoize-anydbm-file perl-module-io-uncompress-bunzip2 perl-module-net-netent perl-module-validate perl-module-archive-extract perl-module-io-dir perl-module-pod-simple-text vte-termcap perl-module-unicode-collate-locale-lt perl-module-parse-cpan-meta perl-module-locale-codes-language perl-module-time-localtime perl-module-getopts libgomp gettext perl-module-dbm-filter-compress perl-module-unicode-collate-locale-fr perl-module-unicode-collate-locale-sk eglibc-localedata-iso14651-t1 perl-module-digest-base packagegroup-core-x11-xserver perl-module-if perl-module-unicode-collate-locale-pl perl-module-extutils-cbuilder-platform-unix perl-module-bigfloat perl-module-unicode-collate-locale-ro perl-module-pod-text-termcap perl-module-cgi-cookie libxfont perl-module-integer perl-module-findbin xf86-video-omap perl-module-net-smtp gcc run-postinsts perl-module-filter-util-call avahi-daemon dbus-lib perl-module-flush perl-module-extutils-embed perl-module-pod-simple-checker perl-module-json-pp perl-module-pod-simple packagegroup-core-x11-sato-apps perl-module-unicode-collate-locale-uk perl-module-cgi-pretty perl-module-math-bigint-calc linux-libc-headers-dev perl-module-filehandle perl-module-io-uncompress-anyinflate perl-module-io-compress-zip-constants perl-module-encode-gsm0338 perl-module-encode-cjkconstants perl-module-unicode-collate-locale-sq kernel-dev util-linux-readprofile gst-meta-base perl-module-file-temp perl-module-open3 glib-2.0 perl-module-pod-select matchbox-desktop-sato xserver-xorg-module-exa perl-module-encode-byte gst-meta-x11-base gmp perl-module-extutils-my perl-module-dotsh perl-module-tap-parser perl-module-unicode-collate-locale-ja perl-module-net-cmd perl-module-config-extensions perl-module-threads gstreamer perl-module-pod-find perl-module-pod-html distcc perl-module-tap-formatter-session libxcomposite eglibc-gconv-ibm850 perl-module-gdbm-file perl-module-unicode-collate-locale-de-phone libusb-compat mtdev libstdc++-dev perl-module-syslog perl-module-pod-perldoc-tonroff perl-module-extutils-install perl-module-io-file perl-module-hostname perl-module-time-hires perl-module-app-prove-state atk perl-module-shell perl-module-log-message-config perl-module-metadata perl-module-time-local udev perl-module-base perl-module-tap-parser-grammar perl-module-params-check perl-module-net-ftp-a xserver-xf86-config perl-module-extutils-manifest fontconfig perl-module-cpan perl-module-getcwd modutils-initscripts openssh-sftp-server jpeg perl-module-pod-simple-dumpasxml wpa-supplicant-passphrase intltool kernel-module-ipt-masquerade ncurses-libncursesw perl-module-file-spec-os2 perl-module-extutils-cbuilder-platform-windows-bcc perl-module-unicode-collate-locale-vi perl-module-perl-ostype perl-module-b perl-module-file-fetch wpa-supplicant perl-module-unicode-collate-locale-cs perl-module-file-spec-win32 gdbserver libx11 perl-module-io-uncompress-adapter-identity perl-module-tap-parser-sourcehandler-handle perl-module-extutils-mm-nw5 perl-module-io perl-module-unicode-collate-locale-fil perl-module-io-handle perl-module-sort libgcc perl-module-unicode-collate-locale-mt libxi perl-module-io-compress-zlib-constants util-linux-libmount perl-module-extutils-liblist-kid perl-module-ipc-cmd perl-module-overload kernel-module-nf-defrag-ipv4 perl-module-assert perl-module-encode-jp libgettextsrc perl-module-dbm-filter perl-module-perlio-via-quotedprint perl-module-pod-parseutils perl-module-locale-currency dpkg gettext-dev perl-module-unicode-collate-locale-is perl-module-dynaloader perl-module-selfloader perl-module-pod-simple-transcode perl-module-tap-parser-result-bailout libxcb-shm perl-module-io-uncompress-gunzip pcmanfm libfontenc perl-module-memoize-expire perl-module-io-compress-rawdeflate perl-module-unicode-collate-locale-hu libgstaudio-0.10 perl-module-config-git perl-module-locale-country ofono perl-module-term-ui libffi libgstriff-0.10 bluez4 perl-module-net-time gst-plugins-base perl-module-data-dumper libnl-genl base-files perl-module-unicode-collate-locale-ko ncurses-libtinfo perl-module-tap-parser-sourcehandler-executable libgpg-error libgomp-dev perl-module-universal perl-module-unicode-collate-locale-wo perl-module-io-compress-base-common perl-lib perl-module-file-glob libxcb-dri2 perl-module-ops perl-module-pod-simple-tiedoutfh perl-module-tap-harness perl-module-bytes libxdmcp perl-module-encode-mime-header libqtgui4 perl-module-find perl-module-thread-semaphore perl-module-autodie perl-module-attributes perl-module-anydbm-file eglibc-utils libvte libxinerama gst-plugins-base-xvimagesink perl-module-ipc-sharedmem perl-module-autodie-exception matchbox-panel-2 perl-module-tap-parser-result-yaml perl-module-unicode-collate-locale-ha perl-module-extutils-mm-darwin perl-module-look perl-module-bigrat perl-module-term-ansicolor perl-module-pod-simple-pullparserendtoken perl-module-encode-alias perl-module-unicode-collate-locale-nn perl-module-io-uncompress-base perl-module-unicode-collate-locale-zh perl-module-pod-simple-transcodedumb gconf perl-module-diagnostics perl-module-time-seconds libxrandr util-linux-mkfs perl-module-overload-numbers udev-cache perl-module-extutils-cbuilder-platform-cygwin perl-module-user-grent packagegroup-core-sdk perl-module-open tslib-conf libtasn1 packagegroup-core-tools-debug perl-module-net-pop3 xkbcomp perl-module-locale-script perl perl-module-net-ftp-i make perl-module-cacheout perl-module-unicode-collate-locale-nb perl-module-encode-cn-hz perl-module-perlio-scalar perl-module-unicode-collate-locale-tr perl-module-list-util-pp perl-module-pwd perl-module-devel-dprof perl-module-tie-scalar expat-dev gdk-pixbuf-loader-jpeg perl-module-net-ftp-l perl-module-tie-refhash kernel-module-x-tables x11-common sysvinit-pidof perl-module-file-compare perl-module-tap-formatter-console-parallelsession eglibc-localedata-translit-small liberation-fonts g++-symlinks packagegroup-core-buildessential perl-module-io-compress-gzip iptables libattr perl-module-encoding perl-module-unicode-collate-locale-zh-big5 perl-module-log-message-simple perl-module-unicode-collate-locale-zh-pin perl-module-sdbm-file perl-module-pod-checker xinit perl-module-archive-tar perl-module-tap-parser-result-pragma perl-module-text-parsewords perl-module-net-domain perl-module-encode-jp-h2z base-passwd perl-module-io-socket-unix perl-module-version perl-module-tap-parser-iterator-array perl-module-b-terse perl-module-less perl-module-net-config perl-module-getopt-long perl-module-cpanplus gst-plugins-base-playbin perl-module-file-path perl-module-net-ftp-e perl-module-pod-perldoc-toxml perl-module-pod-text perl-module-memoize-expiretest perl-module-threads-shared perl-module-io-compress-bzip2 libtool libxxf86misc perl-module-tap-parser-result-unknown gst-plugins-base-alsa perl-module-io-uncompress-inflate perl-module-encode-changes perl-module-io-compress-zlib-extra perl-module-getopt-std perl-module-archive-tar-file perl-module-importenv perl-module-extutils-cbuilder-platform-windows eglibc-gconv-utf-16 perl-module-unicode-collate-locale-lv perl-module-unicode-collate-cjk-korean perl-module-pluggable perl-module-b-concise perl-module-build freetype perl-module-fcntl gst-plugins-base-videoscale libsdl perl-module-extutils-makemaker-config xauth perl-module-locale-maketext-simple perl-module-unicode-collate-locale-hr perl-module-net-nntp libsm xdpyinfo initscripts perl-module-pod-man gst-plugins-base-ffmpegcolorspace perl-module-sigtrap perl-module-pod-perldoc-topod perl-module-scalar-util perl-module-text-abbrev perl-module-unicode-collate-cjk-jisx0208 perl-module-locale-codes-country libice eglibc-localedata-translit-compat libxcursor perl-module-tap-formatter-console libtheora perl-module-dirhandle perl-module-exceptions perl-module-complete perl-module-posix packagegroup-core-eclipse-debug eglibc-localedata-i18n initscripts-functions eglibc-localedata-translit-font perl-module-memoize-expirefile perl-module-unicode-collate-locale-es-trad perl-module-tap-base liblzma binutils perl-module-unicode-collate-locale-fi eglibc-thread-db matchbox-keyboard perl-module-extutils-mkbootstrap libgstvideo-0.10 libmatchbox udev-utils perl-module-io-uncompress-rawinflate popt gst-meta-audio libxml2 perl-module-class-struct xcursor-transparent-theme libxft libstdc++ util-linux-libblkid perl-module-log-message-item perl-module-constant eglibc-binary-localedata-en-gb perl-module-encode-cn perl-module-extutils-makemaker gtk-theme-sato perl-module-encode-readme gtk-sato-engine perl-module-tie-handle perl-module-tap-parser-sourcehandler-file init-ifupdown perl-module-tap-formatter-file-session gst-plugins-good perl-module-encode-config libpng leafpad perl-module-file-spec-vms perl-module-pod-escapes gcc-symlinks perl-module-ipc-msg libxkbfile gst-plugins-good-avi libavahi-core quicky gdb quilt perl-module-pod-perldoc-getoptsoo gst-plugins-base-decodebin perl-module-encode--t libusb1 perl-module-pod-simple-transcodesmart libgl-mesa perl-module-dbm-filter-encode perl-module-pod-simple-htmllegacy gst-plugins-base-audioconvert perl-module-unicode-collate-locale-haw perl-module-pod-simple-methody "
DESCRIPTION = ""
