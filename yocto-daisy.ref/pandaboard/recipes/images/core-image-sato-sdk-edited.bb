inherit core-image
IMAGE_INSTALL = ""
DESCRIPTION = ""
